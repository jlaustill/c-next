#ifndef CHAIN_TYPES_MID_H
#define CHAIN_TYPES_MID_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <chain-types-base.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Waypoint {
    Coordinate position;
    uint32_t id;
} Waypoint;

#ifdef __cplusplus
}
#endif

#endif /* CHAIN_TYPES_MID_H */
