/**
 * Generated by C-Next Transpiler from: namespace-struct-init.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - External C++ namespaced types in struct initialization
#include "SeaDash.hpp"

#include <stdbool.h>

// Variable with struct initializer using named fields
SeaDash::Parse::ParseResult parsed = (SeaDash::Parse::ParseResult){ .data = {0}, .count = 0, .success = false };
