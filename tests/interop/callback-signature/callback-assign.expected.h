/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef CALLBACK_ASSIGN_TEST_H
#define CALLBACK_ASSIGN_TEST_H

#include "callback_types.h"

void my_point_handler(const Point& p);
void test_callback_assign(void);

#endif // CALLBACK_ASSIGN_TEST_H
