#ifndef SCOPE_PRIVATE_FUNCTION_TEST_H
#define SCOPE_PRIVATE_FUNCTION_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-private-function.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Calculator_computeSquare(uint32_t n);
uint32_t Calculator_computeCube(uint32_t n);
uint32_t Calculator_sumOfSquareAndCube(uint32_t n);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_PRIVATE_FUNCTION_TEST_H */
