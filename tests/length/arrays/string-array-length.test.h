#ifndef STRING_ARRAY_LENGTH_TEST_H
#define STRING_ARRAY_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    char arr[4][65][65];
} TestStruct;

/* Function prototypes */
uint32_t TestScope_getGlobalArrayLength(void);
uint32_t TestScope_getScopeArrayLength(void);

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_LENGTH_TEST_H */
