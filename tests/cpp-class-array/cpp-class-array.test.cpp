/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "cpp-class-array.test.h"

// test-transpile-only
// Minimal reproducer for C++ class array bugs
#include "MockDevice.h"

#include <stdint.h>

const uint8_t DEVICE_COUNT = 4;

MockDevice devices[4] = {0};

/* Scope: Test */

void Test_init(void) {
    devices[0].begin(0x48);
}
