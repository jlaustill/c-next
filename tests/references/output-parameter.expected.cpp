/**
 * Generated by C-Next Transpiler from: output-parameter.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-006: Output parameter pattern
// Tests: function writes result to caller's variable
void calculateSum(int32_t a, int32_t b, int32_t& result) {
    result = a + b;
}

int main(void) {
    int32_t x = 10;
    int32_t y = 20;
    int32_t sum = 0;
    calculateSum(x, y, sum);
}
