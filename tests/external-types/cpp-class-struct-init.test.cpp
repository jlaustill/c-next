/**
 * Generated by C-Next Transpiler from: cpp-class-struct-init.test.cnx
 * A safer C for embedded systems
 */

// Issue #517: C++ class struct initialization
// When initializing a C++ class with struct syntax { field: value },
// generate field assignments instead of designated initializers
#include "CppTestClass.hpp"

void test(void) {
    CppTestClass obj = {};
    obj.value = 42;
}

int main(void) {
    test();
}
