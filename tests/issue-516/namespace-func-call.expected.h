#ifndef NAMESPACE_FUNC_CALL_TEST_H
#define NAMESPACE_FUNC_CALL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Test_run(void);

#ifdef __cplusplus
}
#endif

#endif /* NAMESPACE_FUNC_CALL_TEST_H */
