/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "const-array-edge-cases.test.h"

#include <stdint.h>
#include <stdbool.h>

// Tests: Edge cases for const-based array dimensions
// Verifies comprehensive coverage for issue #455
// Hex constant - should resolve to 16
const uint8_t HEX_SIZE = 0x10;

// Binary constant - should resolve to 10
const uint8_t BIN_SIZE = 0b1010;

// Array using hex constant
bool hex_arr[16] = {0};

// Array using binary constant
int16_t bin_arr[10] = {0};

// Array inside a scope using top-level constant
const uint8_t BUFFER_SIZE = 8;

/* Scope: Device */
uint8_t Device_buffer[8] = {0};

int main(void) {
    Device_buffer[0] = 1;
}
