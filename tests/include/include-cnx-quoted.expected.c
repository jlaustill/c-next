/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

/* test-execution */
// ADR-010: C Interoperability - Include C-Next files with quotes
// Tests: #include "file.cnx" transpiles to #include "file.h"
#include "helper-types.h"

#include <stdint.h>

uint32_t main(void) {
    Point p = {0};
    p.x = 5;
    return 0;
}
