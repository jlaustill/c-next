#ifndef HEADER_NAMESPACE_EXTERN_TEST_H
#define HEADER_NAMESPACE_EXTERN_TEST_H

/**
 * Generated by C-Next Transpiler from: header-namespace-extern.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* HEADER_NAMESPACE_EXTERN_TEST_H */
