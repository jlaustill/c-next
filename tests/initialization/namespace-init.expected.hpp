#ifndef NAMESPACE_INIT_TEST_H
#define NAMESPACE_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: namespace-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t globalCount;

/* Function prototypes */
void Counter_init(void);
void Counter_increment(void);

#ifdef __cplusplus
}
#endif

#endif /* NAMESPACE_INIT_TEST_H */
