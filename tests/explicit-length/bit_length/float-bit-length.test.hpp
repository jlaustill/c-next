#ifndef FLOAT_BIT_LENGTH_TEST_H
#define FLOAT_BIT_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    float x;
    double y;
} TestStruct;

/* External variables */
extern float globalF32;
extern double globalF64;

#ifdef __cplusplus
}
#endif

#endif /* FLOAT_BIT_LENGTH_TEST_H */
