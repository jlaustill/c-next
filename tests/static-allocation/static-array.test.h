#ifndef STATIC_ARRAY_TEST_H
#define STATIC_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t rxBuffer[256];
extern uint8_t txBuffer[128];

#ifdef __cplusplus
}
#endif

#endif /* STATIC_ARRAY_TEST_H */
