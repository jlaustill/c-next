/**
 * Generated by C-Next Transpiler from: division-non-zero-const.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-051: Division by non-zero constant should compile
extern const uint32_t TEN = 10U;

void testNonZeroConst(void) {
    uint32_t result = 100U / TEN;
}
