/**
 * Generated by C-Next Transpiler from: args-element-count.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// Tests args.element_count property (ADR-058)
// args.element_count returns argc
int main(int argc, char *argv[]) {
    uint32_t count = argc;
    if (count < 1) {
        return 1;
    }
    return 0;
}
