/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.test.h"

// test-transpile-only
#include "fake_lib.h"

/* Scope: MyScope */
static widget_t MyScope_w = {0};

void MyScope_init(void) {
    MyScope_w = widget_create();
    widget_set_value(&MyScope_w, 42);
}
