#ifndef PRIVATE_FUNC_ACCESS_ERROR_TEST_H
#define PRIVATE_FUNC_ACCESS_ERROR_TEST_H

/**
 * Generated by C-Next Transpiler from: private-func-access-error.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Service_internalHelper(void);

#ifdef __cplusplus
}
#endif

#endif /* PRIVATE_FUNC_ACCESS_ERROR_TEST_H */
