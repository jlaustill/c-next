#ifndef LENGTH_PROPERTY_ARRAY_MEMBERS_TEST_H
#define LENGTH_PROPERTY_ARRAY_MEMBERS_TEST_H

/**
 * Generated by C-Next Transpiler from: length-property-array-members.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct DataPoint {
    uint32_t timestamp;
    uint16_t value;
    uint8_t quality;
} DataPoint;
typedef struct Dataset {
    uint32_t id;
    DataPoint samples[10];
    uint8_t count;
} Dataset;

#ifdef __cplusplus
}
#endif

#endif /* LENGTH_PROPERTY_ARRAY_MEMBERS_TEST_H */
