#ifndef ENUM_CROSS_SCOPE_RETURN_TEST_H
#define ENUM_CROSS_SCOPE_RETURN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ECategory_CAT_A = 0,
    ECategory_CAT_B = 1
} ECategory;

/* Function prototypes */
ECategory Provider_getCategory(void);
uint32_t Consumer_test(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_CROSS_SCOPE_RETURN_TEST_H */
