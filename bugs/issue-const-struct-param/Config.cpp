/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Shared config struct
typedef struct Config {
    uint32_t value;
} Config;
