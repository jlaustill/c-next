/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "Serial.hpp"

#include <stdint.h>

// test-cpp-only
// Mock Serial for logging - does NOT modify Config
/* Scope: Serial */

void Serial_println(uint32_t msg) {
}
