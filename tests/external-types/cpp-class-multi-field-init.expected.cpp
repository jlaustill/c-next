/**
 * Generated by C-Next Transpiler from: cpp-class-multi-field-init.test.cnx
 * A safer C for embedded systems
 */

// Issue #517: C++ class multi-field struct initialization
// Multiple fields should generate multiple assignments
#include "CppTestClass.hpp"

void test(void) {
    CppTestClass obj = {};
    obj.value = 100;
    obj.name = "test";
}

int main(void) {
    test();
}
