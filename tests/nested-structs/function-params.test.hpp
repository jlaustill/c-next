#ifndef FUNCTION_PARAMS_TEST_H
#define FUNCTION_PARAMS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Rectangle {
    Point topLeft;
    Point bottomRight;
} Rectangle;

/* External variables */
extern Rectangle bounds;

#ifdef __cplusplus
}
#endif

#endif /* FUNCTION_PARAMS_TEST_H */
