/**
 * Generated by C-Next Transpiler from: string-concat-literal.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test string concatenation with literal
void test(void) {
    char greeting[33] = "Hello";
    char result[65] = "";
        strncpy(result, greeting, 64);
        strncat(result, " World", 64 - strlen(result));
        result[64] = '\0';
}
