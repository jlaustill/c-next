/**
 * Generated by C-Next Transpiler from: level1.cnx
 * A safer C for embedded systems
 */

#include "level1.h"

// Middle level - includes level2 and uses its enum
#include "level2.h"

/* Scope: NestedExtEnum */

void setMedium(NestedExtEnum_Config* cfg) {
    cfg->level = ELevel_LEVEL_MEDIUM;
}
