/**
 * Generated by C-Next Transpiler from: main-2d-array.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: 2D array parameter syntax
int main(int argc, char *argv[]) {
    return 0;
}
