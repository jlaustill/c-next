/**
 * Generated by C-Next Transpiler from: struct-member-unsigned-shift.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Unsigned compound shift-assign on struct members should be allowed
// Verifies that the struct member resolution doesn't over-reject
typedef struct Data {
    uint8_t value;
} Data;

int main(void) {
    Data d = { .value = 1U };
    d.value <<= 2U;
    if (d.value != 4) return 1;
    d.value = 16U;
    d.value >>= 2U;
    if (d.value != 4) return 2;
    return 0;
}
