/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "enum-array-size-header.test.h"

#include <stdint.h>

// Same-file enum value used as array size in header (fixed in v0.1.65)
// Cross-file case tested in tests/enum-external/enum-array-dimension.test.cnx
extern const uint8_t DATA[EColor_COUNT] = {10U, 20U, 30U};

/* Scope: Test */

uint8_t Test_get(uint8_t idx) {
    return DATA[idx];
}
