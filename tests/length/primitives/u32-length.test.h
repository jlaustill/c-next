#ifndef U32_LENGTH_TEST_H
#define U32_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    uint32_t member;
} TestStruct;

/* External variables */
extern uint32_t globalVar;
extern uint32_t TestScope_publicMember;

/* Function prototypes */
uint32_t TestScope_getGlobalLength(void);
uint32_t TestScope_getMemberLength(void);

#ifdef __cplusplus
}
#endif

#endif /* U32_LENGTH_TEST_H */
