#ifndef BARE_SCOPE_MEMBER_TEST_H
#define BARE_SCOPE_MEMBER_TEST_H

/**
 * Generated by C-Next Transpiler from: bare-scope-member.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Counter_increment(void);
uint32_t Counter_getValue(void);

#ifdef __cplusplus
}
#endif

#endif /* BARE_SCOPE_MEMBER_TEST_H */
