#ifndef FLAG_DEFINE_VALID_TEST_H
#define FLAG_DEFINE_VALID_TEST_H

/**
 * Generated by C-Next Transpiler from: flag-define-valid.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t LED_PIN;
extern const uint32_t ALT_PIN;

#ifdef __cplusplus
}
#endif

#endif /* FLAG_DEFINE_VALID_TEST_H */
