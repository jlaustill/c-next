/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Focused test: Compound assignment on array-of-struct member
// Bug: arr[i].field +<- value generates arr[i].field = value (loses the +=)
typedef struct {
    int32_t value;
} Counter;

Counter counters[2] = {0};

int32_t main(void) {
    counters[0].value = 100;
    counters[1].value = 200;
    counters[0].value += 10;
    counters[1].value -= 50;
    if (counters[0].value != 110) {
        return 1;
    }
    if (counters[1].value != 150) {
        return 1;
    }
    return 0;
}
