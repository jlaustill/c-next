#ifndef ISSUE_328_FALSE_SYMBOL_CONFLICT_TEST_H
#define ISSUE_328_FALSE_SYMBOL_CONFLICT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <Display/AppData.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern AppData sensorData;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_328_FALSE_SYMBOL_CONFLICT_TEST_H */
