/**
 * Generated by C-Next Transpiler from: include-passthrough.test.cnx
 * A safer C for embedded systems
 */

// test-execution
// ADR-010: C Interoperability - Include passthrough
// Tests: #include directives pass through to generated C
#include <stdio.h>
#include <string.h>

#include <stdint.h>

int main(void) {
    return 0;
}
