/**
 * Generated by C-Next Transpiler from: string-init-bounded-copy.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// test-execution
// Issue #1044: initializing a string from another string variable must use a
// bounded copy (strncpy + null terminator), not an unbounded strcpy (CWE-120,
// flawfinder MS-banned). This must match the reassignment code path exactly.
int main(void) {
    char small[33] = "Test";
    char big[65] = "";
        strncpy(big, small, 64); big[64] = '\0';
    if (strcmp(big, "Test") != 0) return 1;
    if (strlen(big) != 4) return 2;
    return 0;
}
