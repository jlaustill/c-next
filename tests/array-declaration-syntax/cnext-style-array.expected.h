#ifndef CNEXT_STYLE_ARRAY_TEST_H
#define CNEXT_STYLE_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint16_t myArray[8];
extern uint8_t initialized[4];
extern int32_t signedArray[3];

#ifdef __cplusplus
}
#endif

#endif /* CNEXT_STYLE_ARRAY_TEST_H */
