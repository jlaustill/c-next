#ifndef SLICE_STRUCT_FIELDS_TEST_H
#define SLICE_STRUCT_FIELDS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Forward declarations */
typedef struct Config Config;

/* Function prototypes */
u32 main();

#ifdef __cplusplus
}
#endif

#endif /* SLICE_STRUCT_FIELDS_TEST_H */
