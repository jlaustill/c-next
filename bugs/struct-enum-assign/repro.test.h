#ifndef REPRO_TEST_H
#define REPRO_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EValueId_VALUE_A = 0,
    EValueId_VALUE_B = 1,
    EValueId_VALUE_UNASSIGNED = 255
} EValueId;

/* Struct definitions */
typedef struct TInput {
    EValueId assignedValue;
} TInput;

/* External variables */
extern TInput input;

#ifdef __cplusplus
}
#endif

#endif /* REPRO_TEST_H */
