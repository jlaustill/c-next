#ifndef SHORT_CIRCUIT_SAFETY_TEST_H
#define SHORT_CIRCUIT_SAFETY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TStatusRegister {
    uint32_t enabled;
    uint32_t value;
} TStatusRegister;

/* External variables */
extern uint32_t accessCount;
extern uint32_t dangerousValue;
extern TStatusRegister status;

#ifdef __cplusplus
}
#endif

#endif /* SHORT_CIRCUIT_SAFETY_TEST_H */
