#ifndef STRUCT_MEMBER_ACCESS_TEST_H
#define STRUCT_MEMBER_ACCESS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_MEMBER_ACCESS_TEST_H */
