/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid inline NULL check pattern for stream functions
#include <stdio.h>

#include <string.h>

char buffer[65] = "";

void readInput(void) {
    if (fgets(buffer, 65, stdin) != NULL) {
        printf("Got: %s", buffer);
    }
}
