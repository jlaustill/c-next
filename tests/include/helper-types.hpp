#ifndef HELPER_TYPES_H
#define HELPER_TYPES_H

/**
 * Generated by C-Next Transpiler from: helper-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct HelperTypes_Color {
    uint8_t red;
    uint8_t green;
    uint8_t blue;
} HelperTypes_Color;
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

#ifdef __cplusplus
}
#endif

#endif /* HELPER_TYPES_H */
