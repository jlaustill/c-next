#ifndef CALLBACK_BASIC_TEST_H
#define CALLBACK_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Message {
    uint32_t id;
} Message;
typedef struct Controller {
    onReceive _handler;
} Controller;

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_BASIC_TEST_H */
