#ifndef CONST_F64_VARIABLE_TEST_H
#define CONST_F64_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: const-f64-variable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const double PI_PRECISE;
extern const double E;
extern const double ZERO;

#ifdef __cplusplus
}
#endif

#endif /* CONST_F64_VARIABLE_TEST_H */
