/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.h"

#include <stdbool.h>

// Minimal reproducer for reference body syntax mismatch
// When a function takes a struct by reference, the body still uses pointer syntax
/* Scope: Storage */

bool Storage_validate(const Config& config) {
    if (config.magic != 123) {
        return false;
    }
    return true;
}

void Storage_loadDefaults(Config& config) {
    config.magic = 123;
    config.version = 1;
}

Config Storage_copy(const Config& config) {
    Config result = config;
    return result;
}
