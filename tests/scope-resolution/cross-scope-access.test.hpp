#ifndef CROSS_SCOPE_ACCESS_TEST_H
#define CROSS_SCOPE_ACCESS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void LED_setBrightness(uint8_t level);
uint8_t LED_getBrightness(void);
void Motor_adjustLED(void);

#ifdef __cplusplus
}
#endif

#endif /* CROSS_SCOPE_ACCESS_TEST_H */
