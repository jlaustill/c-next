/**
 * Generated by C-Next Transpiler from: string-empty.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test empty string declaration
char buffer[65] = "";

char largeBuffer[257] = "";
