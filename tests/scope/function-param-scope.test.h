#ifndef FUNCTION_PARAM_SCOPE_TEST_H
#define FUNCTION_PARAM_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
float Math_add(float x, float y);
float Math_multiply(float x, float y);
float Math_subtract(float x, float y);

#ifdef __cplusplus
}
#endif

#endif /* FUNCTION_PARAM_SCOPE_TEST_H */
