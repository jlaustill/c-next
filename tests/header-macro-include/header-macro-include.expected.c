/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Tests: Issue #424 - Generated header includes macro-defining headers
// When a macro from an included header is used in an array size,
// the generated .h file must include that header for the extern declaration.
//
// Note: We avoid accessing the array here because macro-defined array
// sizes have a known limitation with bit-indexing detection.
#include "config.h"

#include <stdint.h>

uint32_t devices[DEVICE_COUNT] = {0};

int main(void) {
    return 0;
}
