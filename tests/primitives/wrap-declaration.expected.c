/**
 * Generated by C-Next Transpiler from: wrap-declaration.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Test wrap keyword in variable declarations
// Explicit wrap modifier for counters
uint8_t byteCounter = 0U;

uint16_t tickCount = 0U;

uint32_t cycleCounter = 0U;

uint64_t systemTicks = 0ULL;
