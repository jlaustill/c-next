#ifndef MODIFIER_H
#define MODIFIER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Modifier_reset(Config& c);

#ifdef __cplusplus
}
#endif

#endif /* MODIFIER_H */
