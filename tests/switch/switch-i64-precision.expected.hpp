#ifndef SWITCH_I64_PRECISION_TEST_H
#define SWITCH_I64_PRECISION_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-i64-precision.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t result;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_I64_PRECISION_TEST_H */
