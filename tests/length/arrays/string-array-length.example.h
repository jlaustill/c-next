#ifndef STRING_ARRAY_LENGTH_TEST_H
#define STRING_ARRAY_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Forward declarations */
typedef struct TestStruct TestStruct;

/* External variables */
extern string<64> globalArr;
extern string<64> TestScope_scopeArr;
extern string<64> TestScope_publicArr;

/* Function prototypes */
u32 TestScope_getGlobalArrayLength();
u32 TestScope_getScopeArrayLength();
u32 checkArrayLength(string<64>);
i32 main();

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_LENGTH_TEST_H */
