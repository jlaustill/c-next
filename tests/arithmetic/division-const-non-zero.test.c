/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-051 Phase 3: Division by const non-zero
// Should compile successfully
const uint32_t TEN = 10U;

const uint32_t FIVE = 5U;

void testDivisionByConstNonZero(void) {
    uint32_t result1 = 100U / TEN;
    uint32_t result2 = 25U / FIVE;
    uint32_t result3 = result1 % TEN;
}
