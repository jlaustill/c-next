#ifndef STRING_CHAR_COUNT_TEST_H
#define STRING_CHAR_COUNT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    char name[33];
} TestStruct;

/* External variables */
extern char globalStr[65];

#ifdef __cplusplus
}
#endif

#endif /* STRING_CHAR_COUNT_TEST_H */
