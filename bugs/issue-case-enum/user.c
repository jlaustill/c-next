/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Test: enum in if vs case
#include "types.h"

void test(ECategory cat) {
    if (cat == ECategory_CAT_A) {
        return;
    }
    switch (cat) {
        case ECategory_CAT_A: {
            break;
        }
        case ECategory_CAT_B: {
            break;
        }
        case ECategory_CAT_C: {
            break;
        }
    }
}
