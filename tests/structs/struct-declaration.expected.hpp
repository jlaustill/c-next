#ifndef STRUCT_DECLARATION_TEST_H
#define STRUCT_DECLARATION_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-declaration.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Color {
    uint8_t r;
    uint8_t g;
    uint8_t b;
    uint8_t a;
} Color;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_DECLARATION_TEST_H */
