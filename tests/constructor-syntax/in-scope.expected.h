#ifndef IN_SCOPE_TEST_H
#define IN_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Adafruit_MAX31856 Adafruit_MAX31856;

/* External variables */
extern const uint8_t Sensor_pin;
extern Adafruit_MAX31856 Sensor_device;

/* Function prototypes */
void Sensor_init(void);

#ifdef __cplusplus
}
#endif

#endif /* IN_SCOPE_TEST_H */
