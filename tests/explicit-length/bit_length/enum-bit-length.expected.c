/**
 * Generated by C-Next Transpiler from: enum-bit-length.test.cnx
 * A safer C for embedded systems
 */

#include "enum-bit-length.test.h"

#include <stdint.h>

// test-execution
// test-c-only
// Tests .bit_length property for enum type (ADR-058)
// Enums are 32 bits by default (ADR-017)
Color globalColor = Color_Red;

/* Scope: EnumBitLen */

int main(void) {
    if (32 != 32) {
        return 1;
    }
    State localState = State_IDLE;
    if (32 != 32) {
        return 2;
    }
    EnumBitLen_TestStruct ts = {0};
    ts.state = State_RUNNING;
    if (32 != 32) {
        return 3;
    }
    return 0;
}
