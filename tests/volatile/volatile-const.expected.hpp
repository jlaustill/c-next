#ifndef VOLATILE_CONST_TEST_H
#define VOLATILE_CONST_TEST_H

/**
 * Generated by C-Next Transpiler from: volatile-const.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t hardware_status;

#ifdef __cplusplus
}
#endif

#endif /* VOLATILE_CONST_TEST_H */
