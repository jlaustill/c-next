#ifndef ALL_TYPES_TEST_H
#define ALL_TYPES_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t byte;
extern uint16_t word;
extern uint32_t dword;
extern uint64_t qword;
extern int8_t sbyte;
extern int16_t sword;
extern int32_t sdword;
extern int64_t sqword;
extern float single;
extern double precise;
extern bool flag;
extern bool ready;

#ifdef __cplusplus
}
#endif

#endif /* ALL_TYPES_TEST_H */
