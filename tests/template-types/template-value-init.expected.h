#ifndef TEMPLATE_VALUE_INIT_TEST_H
#define TEMPLATE_VALUE_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct TemplateType<Param1,Param2,Param3> TemplateType<Param1,Param2,Param3>;
typedef struct Buffer<256,16> Buffer<256,16>;

/* External variables */
extern TemplateType<Param1,Param2,Param3> globalTemplate;
extern Buffer<256,16> globalBuffer;

#ifdef __cplusplus
}
#endif

#endif /* TEMPLATE_VALUE_INIT_TEST_H */
