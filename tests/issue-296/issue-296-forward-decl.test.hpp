#ifndef ISSUE_296_FORWARD_DECL_TEST_H
#define ISSUE_296_FORWARD_DECL_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-296-forward-decl.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <issue-296-types.hpp>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void DataHandler_initialize(const AppData& data);
AppData DataHandler_getData(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_296_FORWARD_DECL_TEST_H */
