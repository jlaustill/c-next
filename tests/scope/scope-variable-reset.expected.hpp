#ifndef SCOPE_VARIABLE_RESET_TEST_H
#define SCOPE_VARIABLE_RESET_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-variable-reset.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Calculator_addAndCount(uint32_t value);
uint32_t Calculator_getOperationCount(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_VARIABLE_RESET_TEST_H */
