/**
 * Generated by C-Next Transpiler from: multiple-headers.test.cnx
 * A safer C for embedded systems
 */

#include "multiple-headers.test.hpp"

// Test: Types from different C headers should include both headers
#include "known-header-types.h"
#include "second-header.h"

/* Scope: Graphics */

Color Graphics_getDefaultColor(void) {
    Color c = (Color){ .r = 255U, .g = 255U, .b = 255U };
    return c;
}

Size Graphics_getDefaultSize(void) {
    Size s = (Size){ .width = 100, .height = 100 };
    return s;
}

int main(void) {
    Color c = Graphics_getDefaultColor();
    Size s = Graphics_getDefaultSize();
}
