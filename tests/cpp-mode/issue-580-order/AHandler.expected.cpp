/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "AHandler.test.h"

// test-cpp-only
// test-transpile-only
// Issue #580 order test: AHandler comes before ZModifier alphabetically
// Tests if file order affects const inference
#include "Config.h"
#include "ZModifier.h"

/* Scope: AHandler */

void AHandler_passThrough(Config& config) {
    ZModifier_reset(config);
}

int main(void) {
    Config c = (Config){ .value = 0 };
    AHandler_passThrough(c);
}
