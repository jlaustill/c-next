#ifndef ESP_STYLE_TEST_H
#define ESP_STYLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void SPI_init(void);
void SPI_write(uint8_t data);

#ifdef __cplusplus
}
#endif

#endif /* ESP_STYLE_TEST_H */
