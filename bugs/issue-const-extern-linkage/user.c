/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "user.h"

// Bug #525: Test accessing const from another file
#include "config.h"

#include <stdint.h>

/* Scope: User */

uint8_t User_getMax(void) {
    return MAX_COUNT;
}
