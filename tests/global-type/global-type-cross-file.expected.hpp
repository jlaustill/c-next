#ifndef GLOBAL_TYPE_CROSS_FILE_TEST_H
#define GLOBAL_TYPE_CROSS_FILE_TEST_H

/**
 * Generated by C-Next Transpiler from: global-type-cross-file.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <cross-file-types.hpp>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
EPriority TaskManager_getPriority(void);
int32_t TaskManager_priorityToInt(EPriority p);
Vec2 TaskManager_getPosition(void);
int32_t TaskManager_sumVec(const Vec2& v);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_TYPE_CROSS_FILE_TEST_H */
