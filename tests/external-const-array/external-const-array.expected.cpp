/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Tests: Issue #461 - Array dimensions in header should use literal values
// When a constant from an external .cnx file is used in an array size,
// the generated .h file should contain the resolved literal value, not the constant name.
// This is necessary because extern const values aren't compile-time constant expressions in C/C++.
#include "config.h"

#include <stdint.h>
#include <stdbool.h>

bool enabled[4] = {false, false, false, false};

int main(void) {
    enabled[0] = true;
    if (enabled[0] != true) return 1;
    if (enabled[1] != false) return 2;
    return 0;
}
