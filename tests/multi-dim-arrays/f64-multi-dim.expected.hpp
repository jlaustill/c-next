#ifndef F64_MULTI_DIM_TEST_H
#define F64_MULTI_DIM_TEST_H

/**
 * Generated by C-Next Transpiler from: f64-multi-dim.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern double matrix2d[4][8];
extern double cube3d[2][3][4];

#ifdef __cplusplus
}
#endif

#endif /* F64_MULTI_DIM_TEST_H */
