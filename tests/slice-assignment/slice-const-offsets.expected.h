#ifndef SLICE_CONST_OFFSETS_TEST_H
#define SLICE_CONST_OFFSETS_TEST_H

/**
 * Generated by C-Next Transpiler from: slice-const-offsets.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t OFFSET_MAGIC;
extern const uint32_t OFFSET_VERSION;
extern const uint32_t OFFSET_FLAGS;
extern const uint8_t LEN_MAGIC;
extern const uint8_t LEN_VERSION;
extern const uint8_t LEN_FLAGS;

#ifdef __cplusplus
}
#endif

#endif /* SLICE_CONST_OFFSETS_TEST_H */
