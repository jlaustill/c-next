/**
 * Generated by C-Next Transpiler from: private-func-access-error.test.cnx
 * A safer C for embedded systems
 */

#include "private-func-access-error.test.h"

// Test: Calling private scope function from outside should error
// This should fail with a visibility error per ADR-016
/* Scope: Service */

void Service_internalHelper(void) {
}

int main(void) {
    Service_internalHelper();
}
