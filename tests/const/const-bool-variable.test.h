#ifndef CONST_BOOL_VARIABLE_TEST_H
#define CONST_BOOL_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: const-bool-variable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const bool FEATURE_ENABLED;
extern const bool DEBUG_MODE;

#ifdef __cplusplus
}
#endif

#endif /* CONST_BOOL_VARIABLE_TEST_H */
