#ifndef ISSUE_315_CROSS_FILE_PRIMITIVE_ARGS_TEST_H
#define ISSUE_315_CROSS_FILE_PRIMITIVE_ARGS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <TestFunc.hpp>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestData {
    float value1;
    float value2;
} TestData;

/* Function prototypes */
void TestCaller_init(void);
float TestCaller_test(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_315_CROSS_FILE_PRIMITIVE_ARGS_TEST_H */
