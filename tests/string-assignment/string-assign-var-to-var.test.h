#ifndef STRING_ASSIGN_VAR_TO_VAR_TEST_H
#define STRING_ASSIGN_VAR_TO_VAR_TEST_H

/**
 * Generated by C-Next Transpiler from: string-assign-var-to-var.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char source[65];
extern char dest[65];

#ifdef __cplusplus
}
#endif

#endif /* STRING_ASSIGN_VAR_TO_VAR_TEST_H */
