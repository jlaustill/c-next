#ifndef SWITCH_MISRA_16_4_DEFAULT_TEST_H
#define SWITCH_MISRA_16_4_DEFAULT_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-misra-16-4-default.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Status_OK = 0,
    Status_ERROR = 1,
    Status_PENDING = 2
} Status;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_MISRA_16_4_DEFAULT_TEST_H */
