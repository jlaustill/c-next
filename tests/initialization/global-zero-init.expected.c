/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

/* test-execution */
// ADR-015: Global zero initialization
// Tests: globals are automatically zero-initialized
uint32_t counter = 0;

int32_t offset = 0;

bool flag = false;

uint8_t byte = 0;

int main(void) {
    if (counter == 0 && offset == 0 && flag == false && byte == 0) {
        return 0;
    }
    return 1;
}
