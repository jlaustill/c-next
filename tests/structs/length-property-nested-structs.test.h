#ifndef LENGTH_PROPERTY_NESTED_STRUCTS_TEST_H
#define LENGTH_PROPERTY_NESTED_STRUCTS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Inner {
    uint32_t value;
    uint16_t status;
} Inner;
typedef struct Outer {
    Inner inner;
    uint8_t flags;
} Outer;
typedef struct DeepNest {
    Outer outer;
    uint64_t timestamp;
} DeepNest;

#ifdef __cplusplus
}
#endif

#endif /* LENGTH_PROPERTY_NESTED_STRUCTS_TEST_H */
