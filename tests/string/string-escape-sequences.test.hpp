#ifndef STRING_ESCAPE_SEQUENCES_TEST_H
#define STRING_ESCAPE_SEQUENCES_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct string string;

/* External variables */
extern char withNewline[65];
extern char withTab[65];
extern char withCarriageReturn[65];
extern char withBackslash[65];
extern char withQuote[65];
extern char multipleEscapes[65];
extern char justNewline[9];
extern char justTab[9];
extern char escapeAtStart[33];
extern char escapeAtEnd[33];
extern const string VERSION_INFO;

#ifdef __cplusplus
}
#endif

#endif /* STRING_ESCAPE_SEQUENCES_TEST_H */
