#ifndef ISR_ASSIGNMENT_TEST_H
#define ISR_ASSIGNMENT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern ISR currentHandler;

#ifdef __cplusplus
}
#endif

#endif /* ISR_ASSIGNMENT_TEST_H */
