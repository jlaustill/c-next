#ifndef SHADOWING_TEST_TEST_H
#define SHADOWING_TEST_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t globalFlags;

/* Function prototypes */
void Control_setFlag(void);
uint8_t Control_getFlags(void);

#ifdef __cplusplus
}
#endif

#endif /* SHADOWING_TEST_TEST_H */
