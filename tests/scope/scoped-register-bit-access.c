/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: Bit indexing on scoped registers
/* Scope: Board */
uint32_t Board_LED_BIT = 3;

/* Register: Board_GPIO @ 0x40000000 */
#define Board_GPIO_DR (*(volatile uint32_t*)(0x40000000 + 0x00))
#define Board_GPIO_DR_SET (*(volatile uint32_t*)(0x40000000 + 0x84))


void Board_toggleLed(void) {
    Board_GPIO_DR_SET = (1 << 3);
}

void main(void) {
    Board_toggleLed();
    Board_GPIO_DR = (Board_GPIO_DR & ~(1 << 0)) | ((true ? 1 : 0) << 0);
}
