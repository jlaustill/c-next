#ifndef NESTED_SUBSCRIPT_TEST_H
#define NESTED_SUBSCRIPT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TInput {
    uint8_t assignedValue;
} TInput;

/* External variables */
extern TInput inputs[8];

/* Function prototypes */
void Test_setInput(const uint8_t data[8]);
void Test_setInputExtracted(const uint8_t data[8]);

#ifdef __cplusplus
}
#endif

#endif /* NESTED_SUBSCRIPT_TEST_H */
