#ifndef ISR_ARRAY_TEST_H
#define ISR_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler from: isr-array.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern ISR vectorTable[3];

#ifdef __cplusplus
}
#endif

#endif /* ISR_ARRAY_TEST_H */
