/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-035: Basic Array Initialization Test
// Tests: explicit size with values
// Fixed size array with values
uint8_t data[5] = {1, 2, 3, 4, 5};

// Different types
uint16_t words[3] = {100, 200, 300};

int32_t signedNums[4] = {-1, 0, 1, 2};
