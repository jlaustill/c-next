#ifndef HELLO_WORLD_TEST_H
#define HELLO_WORLD_TEST_H

/**
 * Generated by C-Next Transpiler from: hello-world.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char userName[51];

#ifdef __cplusplus
}
#endif

#endif /* HELLO_WORLD_TEST_H */
