#ifndef OPAQUE_LOCALS_DIRECT_CALL_TEST_H
#define OPAQUE_LOCALS_DIRECT_CALL_TEST_H

/**
 * Generated by C-Next Transpiler from: opaque-locals-direct-call.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void DirectDisplay_init(void);

#ifdef __cplusplus
}
#endif

#endif /* OPAQUE_LOCALS_DIRECT_CALL_TEST_H */
