#ifndef ENUM_THIS_METHOD_TEST_H
#define ENUM_THIS_METHOD_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-this-method.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Motor_EMode_OFF = 0,
    Motor_EMode_ON = 1
} Motor_EMode;

/* Function prototypes */
Motor_EMode Motor_getMode(void);
bool Motor_test(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_THIS_METHOD_TEST_H */
