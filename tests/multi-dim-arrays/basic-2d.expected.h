#ifndef BASIC_2D_TEST_H
#define BASIC_2D_TEST_H

/**
 * Generated by C-Next Transpiler from: basic-2d.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t matrix[4][8];

#ifdef __cplusplus
}
#endif

#endif /* BASIC_2D_TEST_H */
