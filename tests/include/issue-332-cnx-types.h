/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#ifndef ISSUE_332_CNX_TYPES_H
#define ISSUE_332_CNX_TYPES_H

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Issue #332: C-Next struct for testing pointer parameter handling */
typedef struct Issue332AppData {
    float value;
    uint32_t count;
} Issue332AppData;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_332_CNX_TYPES_H */
