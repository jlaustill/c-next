#ifndef STRING_LENGTH_REPEATED_TEST_H
#define STRING_LENGTH_REPEATED_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char text[65];

#ifdef __cplusplus
}
#endif

#endif /* STRING_LENGTH_REPEATED_TEST_H */
