/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_add_u32(uint32_t a, uint32_t b) {
    if (a > UINT32_MAX - b) return UINT32_MAX;
    return a + b;
}

// ADR-027: Basic do-while loop with comparison condition
void test(void) {
    uint32_t count = 0;
    do {
            count = cnx_clamp_add_u32(count, 1);
    } while (count < 10);
}
