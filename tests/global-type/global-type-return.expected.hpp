#ifndef GLOBAL_TYPE_RETURN_TEST_H
#define GLOBAL_TYPE_RETURN_TEST_H

/**
 * Generated by C-Next Transpiler from: global-type-return.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ETestCategory_TEST_CAT_A = 0,
    ETestCategory_TEST_CAT_B = 1,
    ETestCategory_TEST_CAT_C = 2
} ETestCategory;

/* Function prototypes */
ETestCategory TestScope_getCategory(void);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_TYPE_RETURN_TEST_H */
