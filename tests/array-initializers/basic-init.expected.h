#ifndef BASIC_INIT_TEST_H
#define BASIC_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: basic-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t data[5];
extern uint16_t words[3];
extern int32_t signedNums[4];

#ifdef __cplusplus
}
#endif

#endif /* BASIC_INIT_TEST_H */
