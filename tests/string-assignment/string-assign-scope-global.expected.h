#ifndef STRING_ASSIGN_SCOPE_GLOBAL_TEST_H
#define STRING_ASSIGN_SCOPE_GLOBAL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char globalBuffer[65];

/* Function prototypes */
void Handler_updateGlobal(void);
void Handler_clearGlobal(void);
void Handler_setLongMessage(void);

#ifdef __cplusplus
}
#endif

#endif /* STRING_ASSIGN_SCOPE_GLOBAL_TEST_H */
