#ifndef THIS_GLOBAL_TEST_TEST_H
#define THIS_GLOBAL_TEST_TEST_H

/**
 * Generated by C-Next Transpiler from: this-global-test.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t globalValue;

/* Function prototypes */
uint8_t Motor_getLocalValue(void);
uint8_t Motor_getGlobalValue(void);
uint8_t Motor_getSum(void);
void Motor_setState(uint8_t val);

#ifdef __cplusplus
}
#endif

#endif /* THIS_GLOBAL_TEST_TEST_H */
