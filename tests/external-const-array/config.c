/**
 * Generated by C-Next Transpiler from: config.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Configuration constants for external-const-array test
// Tests: Issue #461 - Array dimensions should use literal values from external constants
const uint8_t DEVICE_COUNT = 4U;
