/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// E0504: Including .h without .cnx alternative should NOT produce error
// TestConfig.h exists but TestConfig.cnx does NOT
#include "TestConfig.h"

#include <stdint.h>

int main(void) {
    return 0;
}
