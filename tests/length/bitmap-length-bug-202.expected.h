#ifndef BITMAP_LENGTH_BUG_202_TEST_H
#define BITMAP_LENGTH_BUG_202_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Bitmaps */
/* Bitmap: Flags
 *   bit0: bit 0
 *   bit1: bit 1
 *   bit2: bit 2
 *   bit3: bit 3
 *   bit4: bit 4
 *   bit5: bit 5
 *   bit6: bit 6
 *   bit7: bit 7
 */
typedef uint8_t Flags;

#ifdef __cplusplus
}
#endif

#endif /* BITMAP_LENGTH_BUG_202_TEST_H */
