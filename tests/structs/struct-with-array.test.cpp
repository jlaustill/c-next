/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-014: Struct with array member
// Tests: array fields inside structs
typedef struct Buffer {
    uint8_t data[16];
    uint32_t len;
} Buffer;

int main(void) {
    Buffer buf = {0};
    buf.len = 0;
    buf.data[0] = 0x41;
    buf.data[1] = 0x42;
    buf.len = 2;
}
