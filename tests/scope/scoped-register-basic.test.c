/**
 * Generated by C-Next Transpiler from: scoped-register-basic.test.cnx
 * A safer C for embedded systems
 */

#include "scoped-register-basic.test.h"

#include <stdint.h>

// Test: Basic scoped register declaration and access
/* Scope: Teensy4 */

/* Register: Teensy4_GPIO7 @ 0x42004000 */
#define Teensy4_GPIO7_DR (*(volatile uint32_t*)(0x42004000 + 0x00))
#define Teensy4_GPIO7_DR_SET (*(volatile uint32_t*)(0x42004000 + 0x84))
#define Teensy4_GPIO7_DR_TOGGLE (*(volatile uint32_t*)(0x42004000 + 0x8C))


int main(void) {
    Teensy4_GPIO7_DR_SET = 8;
}
