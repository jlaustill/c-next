/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// test-execution
// ADR-007: Single bit write
// Tests: setting individual bits in integer
int main(void) {
    uint8_t flags = 0U;
    flags = (flags & ~(1U << 0)) | (1U << 0);
    flags = (flags & ~(1U << 3)) | (1U << 3);
    flags = (flags & ~(1U << 7)) | (1U << 7);
    if (flags != 0x89) {
        return 1;
    }
    flags = (flags & ~(1U << 3)) | (0U << 3);
    if (flags == 0x81) {
        return 0;
    }
    return 1;
}
