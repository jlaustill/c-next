#ifndef ISSUE_294_DECODER_H
#define ISSUE_294_DECODER_H

/**
 * Generated by C-Next Transpiler from: issue-294-decoder.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint16_t decoder_getSpn(const uint8_t data[8]);
uint8_t decoder_getByte(const uint8_t data[8], uint8_t index);
uint8_t decoder_internalHelper(uint8_t val);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_294_DECODER_H */
