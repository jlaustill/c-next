#ifndef REASSIGN_CALL_IN_CONDITIONAL_TEST_H
#define REASSIGN_CALL_IN_CONDITIONAL_TEST_H

/**
 * Generated by C-Next Transpiler from: reassign-call-in-conditional.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct ConstCond_Config {
    uint32_t value;
    bool enabled;
} ConstCond_Config;

/* Function prototypes */
uint8_t CommandHandler_setValue(ConstCond_Config* cfg, uint32_t val);
uint8_t CommandHandler_enable(ConstCond_Config* cfg);

#ifdef __cplusplus
}
#endif

#endif /* REASSIGN_CALL_IN_CONDITIONAL_TEST_H */
