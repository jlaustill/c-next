#ifndef STRING_BYTE_TO_U8_PARAM_TEST_H
#define STRING_BYTE_TO_U8_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler from: string-byte-to-u8-param.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t ByteProcessor_processByte(uint32_t crc, uint8_t byte);
uint32_t ByteProcessor_processBuffer(void);

#ifdef __cplusplus
}
#endif

#endif /* STRING_BYTE_TO_U8_PARAM_TEST_H */
