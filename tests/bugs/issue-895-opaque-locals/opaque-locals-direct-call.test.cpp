/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "opaque-locals-direct-call.test.h"

// test-transpile-only
// Issue #895 Bug B: Test direct C function calls (without global. prefix)
// When calling C functions directly, pointer inference should still work.
#include "widget.h"

#include <stdint.h>

void test_direct_call(void) {
    widget_t* w = widget_create(480, 320);
    int32_t width = widget_get_width(w);
    widget_destroy(w);
}

/* Scope: DirectDisplay */

void DirectDisplay_init(void) {
    widget_t* screen = widget_create(800, 600);
    widget_destroy(screen);
}
