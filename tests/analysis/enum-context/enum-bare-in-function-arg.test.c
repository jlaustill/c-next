/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// test-execution
// Tests: Bare enum member as function argument resolves via expectedType (Issue #872)
// Note: MISRA 7.2 compliance requires expectedType for unsigned literals, which
// enables bare enum resolution as a beneficial side effect.
typedef enum {
    Mode_OFF = 0,
    Mode_ON = 1
} Mode;

bool isOn(Mode m) {
    return m == Mode_ON;
}

int main(void) {
    bool result = isOn(Mode_ON);
    return 0;
}
