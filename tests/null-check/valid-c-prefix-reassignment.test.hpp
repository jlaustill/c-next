#ifndef VALID_C_PREFIX_REASSIGNMENT_TEST_H
#define VALID_C_PREFIX_REASSIGNMENT_TEST_H

/**
 * Generated by C-Next Transpiler from: valid-c-prefix-reassignment.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char haystack[65];

#ifdef __cplusplus
}
#endif

#endif /* VALID_C_PREFIX_REASSIGNMENT_TEST_H */
