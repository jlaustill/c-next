/**
 * Generated by C-Next Transpiler from: e0908-nested.test.cnx
 * A safer C for embedded systems
 */

// E0908: Nested if blocks with NULL checks
// cppcheck-suppress misra-c2012-21.6
#include <stdio.h>

#include <string.h>

char buffer[257] = "";

void testNested(void) {
    FILE* c_file = fopen("test.txt", "r");
    if (c_file != NULL) {
        char* c_line = fgets(buffer, 257, c_file);
        if (c_line != NULL) {
            (void)printf("%s", c_line);
        }
        (void)fclose(c_file);
    }
}
