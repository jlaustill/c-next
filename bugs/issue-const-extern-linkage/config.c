/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Bug #525: Top-level const needs extern for C++ external linkage
extern const uint8_t MAX_COUNT = 8;
