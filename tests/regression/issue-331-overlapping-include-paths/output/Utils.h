#ifndef UTILS_H
#define UTILS_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint8_t Utils_add(uint8_t x);
uint8_t Utils_multiply(uint8_t x, uint8_t y);

#ifdef __cplusplus
}
#endif

#endif /* UTILS_H */
