/**
 * Generated by C-Next Transpiler from: bit-single-read.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// test-execution
// ADR-007: Single bit read
// Tests: reading individual bits from integer
int main(void) {
    uint8_t flags = 0b01010101U;
    bool b0 = ((((flags) & 1)) != 0U);
    bool b1 = ((((flags >> 1U) & 1)) != 0U);
    bool b2 = ((((flags >> 2U) & 1)) != 0U);
    bool b7 = ((((flags >> 7U) & 1)) != 0U);
    if (b0 == true && b1 == false && b2 == true && b7 == false) {
        return 0;
    }
    return 1;
}
