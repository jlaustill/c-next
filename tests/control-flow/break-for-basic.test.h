#ifndef BREAK_FOR_BASIC_TEST_H
#define BREAK_FOR_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t main(void);

#ifdef __cplusplus
}
#endif

#endif /* BREAK_FOR_BASIC_TEST_H */
