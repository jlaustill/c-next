#ifndef GLOBAL_TYPE_VARIABLE_TEST_H
#define GLOBAL_TYPE_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EState_IDLE = 0,
    EState_RUNNING = 1,
    EState_STOPPED = 2
} EState;

/* Function prototypes */
void StateMachine_setState(EState state);
EState StateMachine_getState(void);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_TYPE_VARIABLE_TEST_H */
