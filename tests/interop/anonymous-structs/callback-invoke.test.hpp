#ifndef CALLBACK_INVOKE_TEST_H
#define CALLBACK_INVOKE_TEST_H

/**
 * Generated by C-Next Transpiler from: callback-invoke.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t g_callback_value;

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_INVOKE_TEST_H */
