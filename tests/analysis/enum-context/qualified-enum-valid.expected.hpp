#ifndef QUALIFIED_ENUM_VALID_TEST_H
#define QUALIFIED_ENUM_VALID_TEST_H

/**
 * Generated by C-Next Transpiler from: qualified-enum-valid.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Priority_LOW = 1,
    Priority_MEDIUM = 2,
    Priority_HIGH = 3
} Priority;

/* External variables */
extern Priority globalPriority;

#ifdef __cplusplus
}
#endif

#endif /* QUALIFIED_ENUM_VALID_TEST_H */
