/**
 * Generated by C-Next Transpiler from: global-external-struct-array.test.cnx
 * A safer C for embedded systems
 */

#include "global-external-struct-array.test.hpp"

// Issue #612: Array indexing on global external struct field
// This tests that global.structVar.arrayField[N] generates array access,
// not bit-slice code.
#include "External.h"

#include <stdint.h>

ExternalStruct globalExt = {0};

/* Scope: Test */

uint8_t Test_getFromGlobal(void) {
    return globalExt.data[1U];
}

uint8_t Test_getFromParam(const ExternalStruct& ext) {
    return ext.data[1U];
}

uint8_t Test_getCount(void) {
    return globalExt.count;
}
