#ifndef MIXED_SCOPES_TEST_H
#define MIXED_SCOPES_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t MyScope_scopeVar;

#ifdef __cplusplus
}
#endif

#endif /* MIXED_SCOPES_TEST_H */
