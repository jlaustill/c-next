/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #375: Multiple const argument constructor
#include "constructor-stubs.h"

#include <stdint.h>

const uint8_t csPin = 10;

const uint8_t diPin = 11;

const uint8_t doPin = 12;

const uint8_t clkPin = 13;

Adafruit_MAX31856 thermocouple(csPin, diPin, doPin, clkPin);

int main(void) {
}
