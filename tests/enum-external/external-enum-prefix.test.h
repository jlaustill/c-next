#ifndef EXTERNAL_ENUM_PREFIX_TEST_H
#define EXTERNAL_ENUM_PREFIX_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "types.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    EPressureType pType;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* EXTERNAL_ENUM_PREFIX_TEST_H */
