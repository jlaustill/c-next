/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.h"

#include <stdint.h>
#include <stdbool.h>

// Minimal reproducer: atomic/volatile missing from extern declaration in header
volatile TReading readings[4] = {0};

volatile uint32_t counter = 0;

/* Scope: Manager */

void Manager_test(void) {
    readings[0].valid = true;
    counter = counter + 1;
}
