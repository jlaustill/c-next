#ifndef OR_SHORT_CIRCUIT_TEST_H
#define OR_SHORT_CIRCUIT_TEST_H

/**
 * Generated by C-Next Transpiler from: or-short-circuit.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t sideEffectCounter;

#ifdef __cplusplus
}
#endif

#endif /* OR_SHORT_CIRCUIT_TEST_H */
