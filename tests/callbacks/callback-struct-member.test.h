#ifndef CALLBACK_STRUCT_MEMBER_TEST_H
#define CALLBACK_STRUCT_MEMBER_TEST_H

/**
 * Generated by C-Next Transpiler from: callback-struct-member.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Callback typedefs */
typedef uint32_t (*computeValue_fp)(uint32_t);

/* Struct definitions */
typedef struct Processor {
    computeValue_fp handler;
    uint32_t baseValue;
} Processor;

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_STRUCT_MEMBER_TEST_H */
