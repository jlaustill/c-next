#ifndef STRING_STRUCT_CAPACITY_TEST_H
#define STRING_STRUCT_CAPACITY_TEST_H

/**
 * Generated by C-Next Transpiler from: string-struct-capacity.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct StrCapacity_Config {
    char key[33];
    char value[257];
} StrCapacity_Config;
typedef struct Person {
    char name[65];
    char bio[129];
    uint32_t age;
} Person;

#ifdef __cplusplus
}
#endif

#endif /* STRING_STRUCT_CAPACITY_TEST_H */
