#ifndef DIVISION_NON_ZERO_CONST_TEST_H
#define DIVISION_NON_ZERO_CONST_TEST_H

/**
 * Generated by C-Next Transpiler from: division-non-zero-const.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t TEN;

#ifdef __cplusplus
}
#endif

#endif /* DIVISION_NON_ZERO_CONST_TEST_H */
