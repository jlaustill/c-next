#ifndef BARE_FUNCTION_CALL_TEST_H
#define BARE_FUNCTION_CALL_TEST_H

/**
 * Generated by C-Next Transpiler from: bare-function-call.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Calculator_compute(void);
uint32_t Calculator_getResult(void);

#ifdef __cplusplus
}
#endif

#endif /* BARE_FUNCTION_CALL_TEST_H */
