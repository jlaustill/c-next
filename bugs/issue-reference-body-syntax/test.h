#ifndef TEST_H
#define TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    int32_t magic;
    int32_t version;
} Config;

/* Function prototypes */
bool Storage_validate(const Config& config);
void Storage_loadDefaults(Config& config);
Config Storage_copy(const Config& config);

#ifdef __cplusplus
}
#endif

#endif /* TEST_H */
