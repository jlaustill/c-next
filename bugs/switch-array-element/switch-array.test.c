/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "switch-array.test.h"

#include <stdint.h>

// Bug: switch on array element rejected as "boolean type"
/* Scope: Test */

void Test_working(void) {
    uint8_t x = 1;
    switch (x) {
        case 1: {
            break;
        }
        default: {
            break;
        }
    }
}

void Test_failing(void) {
    uint8_t data[4] = {1, 2, 3, 4};
    switch (data[0]) {
        case 1: {
            break;
        }
        default: {
            break;
        }
    }
}
