/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.test.h"

// test-transpile-only
#include "fake_lib.h"

#include <stdint.h>

/* Scope: App */
static widget_t* App_root = NULL;

static void App_on_change(widget_t* w) {
    int32_t val = widget_get_value(w);
}

void App_init(void) {
    widget_t* child = widget_create();
    widget_set_callback(child, App_on_change);
}
