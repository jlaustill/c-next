/**
 * Generated by C-Next Transpiler from: CommandHandler.cnx
 * A safer C for embedded systems
 */

#include "CommandHandler.hpp"

// test-cpp-only
#include "Config.hpp"

#include <stdint.h>

/* Scope: CommandHandler */

uint8_t CommandHandler_setValue(Config& cfg, uint32_t val) {
    cfg.value = val;
    return 0;
}
