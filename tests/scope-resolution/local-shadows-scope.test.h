#ifndef LOCAL_SHADOWS_SCOPE_TEST_H
#define LOCAL_SHADOWS_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: local-shadows-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t State_shadowTest(void);

#ifdef __cplusplus
}
#endif

#endif /* LOCAL_SHADOWS_SCOPE_TEST_H */
