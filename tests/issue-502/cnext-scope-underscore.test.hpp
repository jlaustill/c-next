#ifndef CNEXT_SCOPE_UNDERSCORE_TEST_H
#define CNEXT_SCOPE_UNDERSCORE_TEST_H

/**
 * Generated by C-Next Transpiler from: cnext-scope-underscore.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Motor_State {
    int32_t position;
    bool running;
} Motor_State;
typedef struct Sensor_Reading {
    Motor_State motorState;
    int32_t value;
} Sensor_Reading;

/* External variables */
extern Sensor_Reading reading;

#ifdef __cplusplus
}
#endif

#endif /* CNEXT_SCOPE_UNDERSCORE_TEST_H */
