/**
 * Generated by C-Next Transpiler from: cpp-class-read-before-assign.test.cnx
 * A safer C for embedded systems
 */

// Issue #503: External C++ class variables should not be flagged as uninitialized
// C++ classes with default constructors ARE initialized when declared
// The initialization analyzer should recognize this and not emit E0381
#include "CppMessage.hpp"

#include <stdint.h>

int main(void) {
    CppMessage message = {};
    if (message.pgn == 65280) {
        return 1;
    }
    uint8_t src = message.sourceAddress;
    uint8_t pri = message.priority;
    return 0;
}
