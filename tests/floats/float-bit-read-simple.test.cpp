/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

static_assert(sizeof(float) == 4, "Float bit indexing requires 32-bit float");
static_assert(sizeof(double) == 8, "Float bit indexing requires 64-bit double");

// test-execution
// Simple test for float bit read inside function
int main(void) {
    float testVal = 1.0;
    uint32_t __bits_testVal;
    uint8_t byte3 = (memcpy(&__bits_testVal, &testVal, sizeof(testVal)), ((__bits_testVal >> 24) & 0xFFU));
    if (byte3 != 0x3F) return 1;
    return 0;
}
