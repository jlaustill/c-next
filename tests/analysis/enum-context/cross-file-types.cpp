/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Helper file defining enum for cross-file test
typedef enum {
    ESpnCategory_SPN_CAT_TEMPERATURE = 0,
    ESpnCategory_SPN_CAT_PRESSURE = 1,
    ESpnCategory_SPN_CAT_UNKNOWN = 2
} ESpnCategory;
