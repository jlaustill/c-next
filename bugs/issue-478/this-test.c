/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "this-test.h"

/* Scope: Test */

Test_ECategory Test_getCategory(void) {
    return Test_ECategory_CAT_A;
}
