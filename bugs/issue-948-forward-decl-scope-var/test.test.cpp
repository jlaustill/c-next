/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.test.hpp"

// test-transpile-only
#include "fake_lib.h"

/* Scope: MyScope */
static widget_t MyScope_w = {};

void MyScope_init(void) {
    MyScope_w = widget_create();
    widget_set_value(&MyScope_w, 42);
}
