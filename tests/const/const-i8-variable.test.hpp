#ifndef CONST_I8_VARIABLE_TEST_H
#define CONST_I8_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const int8_t MIN_TEMP;
extern const int8_t MAX_TEMP;
extern const int8_t ZERO_POINT;

#ifdef __cplusplus
}
#endif

#endif /* CONST_I8_VARIABLE_TEST_H */
