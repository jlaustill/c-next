#ifndef NESTED_FORWARD_DECL_TEST_H
#define NESTED_FORWARD_DECL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <nested-forward-decl-types.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Collision_setBounds(const BoundingBox* newBounds);
BoundingBox Collision_getBounds(void);
bool Collision_contains(const Vector2D* point);

#ifdef __cplusplus
}
#endif

#endif /* NESTED_FORWARD_DECL_TEST_H */
