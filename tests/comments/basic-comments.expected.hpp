#ifndef BASIC_COMMENTS_TEST_H
#define BASIC_COMMENTS_TEST_H

/**
 * Generated by C-Next Transpiler from: basic-comments.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;
extern uint32_t maxValue;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_COMMENTS_TEST_H */
