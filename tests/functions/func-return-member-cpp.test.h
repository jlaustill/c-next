#ifndef FUNC_RETURN_MEMBER_CPP_TEST_H
#define FUNC_RETURN_MEMBER_CPP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct DeviceConfig DeviceConfig;

/* External variables */
extern DeviceConfig globalConfig;

#ifdef __cplusplus
}
#endif

#endif /* FUNC_RETURN_MEMBER_CPP_TEST_H */
