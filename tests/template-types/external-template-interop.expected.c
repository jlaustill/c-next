/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #291: Test C++ template interop with C-Next scope
// This demonstrates that template types come from C++ headers (external)
// while scope types are defined in C-Next itself
#include "template-stubs.h"

// External C++ template type (simulating FlexCAN_T4<CAN1, RX_SIZE_256, TX_SIZE_16>)
// In real usage this would come from FlexCAN_T4.h
TemplateType<Param1,Param2,Param3> canBus = 0;

// C-Next defined scope with its own types
/* Scope: CANHandler */

void CANHandler_init(void) {
}

int main(void) {
    CANHandler_init();
}
