/**
 * Generated by C-Next Transpiler from: length-property.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-036: .length on first dimension
uint8_t matrix[4][8] = {0};

int main(void) {
    uint32_t rows = 4;
    return 0;
}
