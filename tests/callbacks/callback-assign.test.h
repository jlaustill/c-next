#ifndef CALLBACK_ASSIGN_TEST_H
#define CALLBACK_ASSIGN_TEST_H

/**
 * Generated by C-Next Transpiler from: callback-assign.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef struct Message Message;

/* Callback typedefs */
typedef void (*onReceive_fp)(Message*);

/* Struct definitions */
typedef struct Message {
    uint32_t id;
} Message;
typedef struct Controller {
    onReceive_fp _handler;
} Controller;

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_ASSIGN_TEST_H */
