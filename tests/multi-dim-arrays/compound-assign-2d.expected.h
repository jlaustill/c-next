#ifndef COMPOUND_ASSIGN_2D_TEST_H
#define COMPOUND_ASSIGN_2D_TEST_H

/**
 * Generated by C-Next Transpiler from: compound-assign-2d.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t matrix[4][4];

#ifdef __cplusplus
}
#endif

#endif /* COMPOUND_ASSIGN_2D_TEST_H */
