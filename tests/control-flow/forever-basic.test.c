/**
 * Generated by C-Next Transpiler from: forever-basic.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Coverage: ADR-113 - forever loop lowers to MISRA-compliant for(;;)
// test-transpile-only
void loopForever(void) {
    uint8_t state = 0U;
    /* MISRA C:2012 Rule 14.3: infinite loop is intentional (C-Next `forever`) */
    for (;;) {
        state = 1U;
    }
}
