/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// EXPECT-ERROR: Modulo operator not supported for floating-point types
// The % operator is only valid for integer types
void test_invalid_modulo(void) {
    float a = 10.5;
    float b = 3.2;
    float result = a % b;
}

void main(void) {
    test_invalid_modulo();
}
