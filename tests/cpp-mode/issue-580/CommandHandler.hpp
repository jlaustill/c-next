#ifndef COMMANDHANDLER_H
#define COMMANDHANDLER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void CommandHandler_reset(Config& config);
void CommandHandler_applyPreset(Config& config, uint8_t input, uint8_t preset);

#ifdef __cplusplus
}
#endif

#endif /* COMMANDHANDLER_H */
