/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "Level1.test.hpp"

// test-cpp-only
// Issue #580 chain test: 3-level deep pass-through chain
// Level1 -> Level2 -> Level3 (modifies)
#include "Config.hpp"
#include "Level2.hpp"

/* Scope: Level1 */

void Level1_entry(Config& config) {
    Level2_passToLevel3(config);
}

int main(void) {
    Config c = (Config){ .value = 0U };
    Level1_entry(c);
}
