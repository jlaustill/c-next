/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "pass-by-value-params.test.h"

#include <stdint.h>
#include <stdbool.h>

// test-transpile-only
// Tests: Header generation with pass-by-value parameters
// Floats, enums, and ISR types should use pass-by-value, not pointers
/* Scope: Api */

float Api_addFloats(float a, float b) {
    return a + b;
}

bool Api_isOk(Status status) {
    return status == Status_Ok;
}

void Api_updateValue(uint32_t& value) {
    value += 1U;
}

uint32_t Api_readValue(uint32_t value) {
    return value * 2;
}
