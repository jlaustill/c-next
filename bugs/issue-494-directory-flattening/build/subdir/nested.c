/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Nested file - should output to src/subdir/nested.c (NOT src/nested.c)
void helper(void) {
    uint32_t x = 42;
}
