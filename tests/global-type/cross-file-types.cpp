/**
 * Generated by C-Next Transpiler from: cross-file-types.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Helper file: defines types used by cross-file tests
// This file is NOT a test file - it provides types for other tests
typedef enum {
    EPriority_LOW = 0,
    EPriority_MEDIUM = 1,
    EPriority_HIGH = 2
} EPriority;

typedef struct Vec2 {
    int32_t x;
    int32_t y;
} Vec2;
