/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "local-shadows-scope.test.h"

#include <stdint.h>

// Test local variable shadows scope member, this. accesses scope
// test-execution
/* Scope: State */
static uint32_t State_value = 100;

uint32_t State_shadowTest(void) {
    uint32_t value = 5;
    State_value = value;
    return State_value;
}

int main(void) {
    uint32_t result = State_shadowTest();
    if (result != 5) return 1;
    return 0;
}
