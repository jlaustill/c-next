/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

typedef enum {
    ECategory_CAT_A = 0,
    ECategory_CAT_B = 1
} ECategory;
