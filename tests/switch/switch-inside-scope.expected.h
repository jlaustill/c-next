#ifndef SWITCH_INSIDE_SCOPE_TEST_H
#define SWITCH_INSIDE_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t globalResult;

/* Function prototypes */
void CommandProcessor_execute(uint32_t command);
uint32_t CommandProcessor_getResult(void);
void Calculator_setOperands(uint32_t x, uint32_t y);
void Calculator_compute(uint32_t operation);
uint32_t Calculator_getOutput(void);

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_INSIDE_SCOPE_TEST_H */
