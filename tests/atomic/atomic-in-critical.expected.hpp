#ifndef ATOMIC_IN_CRITICAL_TEST_H
#define ATOMIC_IN_CRITICAL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint32_t sharedCounter;
extern volatile uint16_t sequence;
extern uint8_t buffer[64];
extern uint32_t writeIdx;

#ifdef __cplusplus
}
#endif

#endif /* ATOMIC_IN_CRITICAL_TEST_H */
