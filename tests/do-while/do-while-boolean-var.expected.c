/**
 * Generated by C-Next Transpiler from: do-while-boolean-var.test.cnx
 * A safer C for embedded systems
 */

#include <stdbool.h>

// ADR-027: Do-while with boolean variable condition
void menuLoop(void) {
    bool running = true;
    do {
        running = false;
    } while (running);
}
