#ifndef STORAGE_H
#define STORAGE_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Storage_loadDefaults(Config& cfg);

#ifdef __cplusplus
}
#endif

#endif /* STORAGE_H */
