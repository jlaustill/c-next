#ifndef BASIC_BITMAP_TEST_H
#define BASIC_BITMAP_TEST_H

/**
 * Generated by C-Next Transpiler from: basic-bitmap.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Bitmaps */
/* Bitmap: MotorFlags
 *   Running: bit 0
 *   Direction: bit 1
 *   Fault: bit 2
 *   Mode: bits 3-5 (3 bits)
 *   Reserved: bits 6-7 (2 bits)
 */
typedef uint8_t MotorFlags;

/* External variables */
extern MotorFlags flags;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_BITMAP_TEST_H */
