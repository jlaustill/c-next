#ifndef SHADOWING_ALL_LEVELS_TEST_H
#define SHADOWING_ALL_LEVELS_TEST_H

/**
 * Generated by C-Next Transpiler from: shadowing-all-levels.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t globalCount;

/* Function prototypes */
uint32_t Counter_testAllLevels(void);

#ifdef __cplusplus
}
#endif

#endif /* SHADOWING_ALL_LEVELS_TEST_H */
