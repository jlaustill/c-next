#ifndef ENUM_GLOBAL_FUNCTION_TEST_H
#define ENUM_GLOBAL_FUNCTION_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EState_OFF = 0,
    EState_ON = 1
} EState;

/* External variables */
extern EState globalState;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_GLOBAL_FUNCTION_TEST_H */
