#ifndef SWITCH_ENUM_UNQUALIFIED_CASE_TEST_H
#define SWITCH_ENUM_UNQUALIFIED_CASE_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-enum-unqualified-case.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ECategory_CAT_A = 0,
    ECategory_CAT_B = 1,
    ECategory_CAT_C = 2
} ECategory;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_ENUM_UNQUALIFIED_CASE_TEST_H */
