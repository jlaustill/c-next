/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "user.h"

#include <config.h>

/* Scope: Test */

ECategory Test_getCategory(void) {
    return ECategory_CAT_A;
}
