/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Root level file - should output to src/root.c
int main(void) {
    return 0;
}
