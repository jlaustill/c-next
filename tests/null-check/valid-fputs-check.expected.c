/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid inline check pattern for fputs (uses EOF not NULL)
#include <stdio.h>

#include <string.h>

char message[33] = "Hello, World!";

void writeOutput(void) {
    if (fputs(message, stdout) != EOF) {
    }
}
