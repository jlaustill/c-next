/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "SerialHandler.h"

#include "Config.h"
#include "CommandHandler.h"

#include <stdint.h>

/* Scope: SerialHandler */

static void SerialHandler_handleSet(Config& config) {
    uint8_t result = CommandHandler_setValue(config, 42);
}

void SerialHandler_process(Config& config) {
    SerialHandler_handleSet(config);
}
