/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-014 + ADR-006: Struct as function parameter
// Tests: pass-by-reference for struct parameters
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

void movePoint(Point& p, int32_t dx, int32_t dy) {
    p.x += dx;
    p.y += dy;
}

int main(void) {
    Point origin = (Point){ .x = 0, .y = 0 };
    int32_t deltaX = 10;
    int32_t deltaY = 20;
    movePoint(origin, deltaX, deltaY);
}
