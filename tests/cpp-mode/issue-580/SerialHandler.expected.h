#ifndef SERIALHANDLER_TEST_H
#define SERIALHANDLER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.h"
#include "CommandHandler.h"
#include "Serial.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Config Config;

/* Function prototypes */
void SerialHandler_handleReset(Config& config);
void SerialHandler_handlePreset(Config& config);
void SerialHandler_handleSave(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* SERIALHANDLER_TEST_H */
