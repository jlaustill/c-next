#ifndef ARRAY_TYPES_H
#define ARRAY_TYPES_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EColor_RED = 0,
    EColor_GREEN = 1,
    EColor_BLUE = 2,
    EColor_COUNT = 3
} EColor;

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_TYPES_H */
