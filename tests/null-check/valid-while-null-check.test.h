#ifndef VALID_WHILE_NULL_CHECK_TEST_H
#define VALID_WHILE_NULL_CHECK_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern bool keepReading;

#ifdef __cplusplus
}
#endif

#endif /* VALID_WHILE_NULL_CHECK_TEST_H */
