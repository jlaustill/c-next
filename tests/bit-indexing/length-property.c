/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-007: The .length property
// Tests: .length returns bit width for integers and element count for arrays
void main(void) {
    uint8_t byte = 0;
    uint16_t word = 0;
    uint32_t dword = 0;
    uint8_t buffer[64] = {0};
    buffer[0] = 0;
    uint32_t byteBits = 8;
    uint32_t wordBits = 16;
    uint32_t dwordBits = 32;
    uint32_t bufLen = 64;
}
