#ifndef ISSUE_68_LENGTH_IN_SERIALIZATION_TEST_H
#define ISSUE_68_LENGTH_IN_SERIALIZATION_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-68-length-in-serialization.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    uint32_t magic;
    uint8_t version;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_68_LENGTH_IN_SERIALIZATION_TEST_H */
