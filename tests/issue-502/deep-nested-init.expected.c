/**
 * Generated by C-Next Transpiler from: deep-nested-init.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - Deeply nested struct initialization with C++ namespaced types
#include "SeaDash.hpp"

#include <stdbool.h>

typedef struct Inner {
    SeaDash::Parse::ParseResult result;
} Inner;

typedef struct Outer {
    Inner inner;
} Outer;

// Deep nesting: Outer -> Inner -> ParseResult
Outer o = (Outer){ .inner = (Inner){ .result = (SeaDash::Parse::ParseResult){ .data = {0}, .count = 0, .success = false } } };
