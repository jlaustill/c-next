#ifndef LENGTH_PROPERTY_CONTROL_FLOW_TEST_H
#define LENGTH_PROPERTY_CONTROL_FLOW_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Packet {
    uint32_t header;
    uint16_t pktLength;
    uint8_t type;
    uint64_t payload;
} Packet;

#ifdef __cplusplus
}
#endif

#endif /* LENGTH_PROPERTY_CONTROL_FLOW_TEST_H */
