#ifndef ISR_BASIC_TEST_H
#define ISR_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler from: isr-basic.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct InterruptController {
    ISR timerCallback;
    ISR uartCallback;
} InterruptController;

#ifdef __cplusplus
}
#endif

#endif /* ISR_BASIC_TEST_H */
