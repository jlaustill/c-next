/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Bug: External enum parameters treated as pass-by-reference
// When an enum is defined in an external header (not parsed by transpiler),
// the transpiler doesn't know it's an enum and treats it as an unknown type,
// using pass-by-reference which fails for enum literals.
#include "external-enum.h"

void useStatus(Status s) {
    Status local = s;
}

int main(void) {
    useStatus(STATUS_OK);
}
