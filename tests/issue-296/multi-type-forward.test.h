#ifndef MULTI_TYPE_FORWARD_TEST_H
#define MULTI_TYPE_FORWARD_TEST_H

/**
 * Generated by C-Next Transpiler from: multi-type-forward.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <multi-type-forward-types.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void DeviceManager_configure(const DeviceConfig* newConfig);
DeviceConfig DeviceManager_getConfig(void);
void DeviceManager_setStatus(const DeviceStatus* newStatus);
DeviceStatus DeviceManager_getStatus(void);
EDeviceState DeviceManager_getState(void);

#ifdef __cplusplus
}
#endif

#endif /* MULTI_TYPE_FORWARD_TEST_H */
