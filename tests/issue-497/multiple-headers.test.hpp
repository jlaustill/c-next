#ifndef MULTIPLE_HEADERS_TEST_H
#define MULTIPLE_HEADERS_TEST_H

/**
 * Generated by C-Next Transpiler from: multiple-headers.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "known-header-types.h"
#include "second-header.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
Color Graphics_getDefaultColor(void);
Size Graphics_getDefaultSize(void);

#ifdef __cplusplus
}
#endif

#endif /* MULTIPLE_HEADERS_TEST_H */
