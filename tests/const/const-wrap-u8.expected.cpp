/**
 * Generated by C-Next Transpiler from: const-wrap-u8.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// ADR-013 + ADR-044: Const wrap u8 combination
// Tests: const wrap u8 declaration and read access
extern const uint8_t FULL_CYCLE = 255U;

extern const uint8_t HALF_CYCLE = 128U;

int main(void) {
    uint8_t full = FULL_CYCLE;
    if (full != 255) return 1;
    uint8_t half = HALF_CYCLE;
    if (half != 128) return 2;
    uint8_t quarter = HALF_CYCLE / 2U;
    if (quarter != 64) return 3;
    return 0;
}
