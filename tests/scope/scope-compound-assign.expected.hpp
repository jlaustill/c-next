#ifndef SCOPE_COMPOUND_ASSIGN_TEST_H
#define SCOPE_COMPOUND_ASSIGN_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-compound-assign.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
int32_t Counter_test(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_COMPOUND_ASSIGN_TEST_H */
