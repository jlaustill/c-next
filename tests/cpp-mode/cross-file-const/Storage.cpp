/**
 * Generated by C-Next Transpiler from: Storage.cnx
 * A safer C for embedded systems
 */

#include "Storage.hpp"

// test-cpp-only
#include "Config.hpp"

/* Scope: Storage */

void Storage_loadDefaults(Config& cfg) {
    cfg.value = 42U;
}
