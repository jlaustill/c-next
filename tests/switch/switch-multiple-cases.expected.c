/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-025: Multiple Cases Test
// Tests case A || B syntax
typedef enum {
    ECommand_READ = 0,
    ECommand_WRITE = 1,
    ECommand_PEEK = 2,
    ECommand_POKE = 3,
    ECommand_ERASE = 4
} ECommand;

void doRead(void) {
}

void doWrite(void) {
}

void doOther(void) {
}

void handleCommand(ECommand* cmd) {
    switch ((*cmd)) {
        case ECommand_READ:
        case ECommand_PEEK: {
            doRead();
            break;
        }
        case ECommand_WRITE:
        case ECommand_POKE: {
            doWrite();
            break;
        }
        default: {
            doOther();
            break;
        }
    }
}
