/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-cpp-mode
typedef struct Config {
    uint32_t value;
} Config;
