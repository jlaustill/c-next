#ifndef APPDATA_H
#define APPDATA_H

/**
 * Generated by C-Next Transpiler from: AppData.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct AppData {
    float humidity;
    float temperature;
} AppData;

#ifdef __cplusplus
}
#endif

#endif /* APPDATA_H */
