#ifndef ARRAY_HANDLES_CNEXT_CALL_TEST_H
#define ARRAY_HANDLES_CNEXT_CALL_TEST_H

/**
 * Generated by C-Next Transpiler from: array-handles-cnext-call.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "fake_lib.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void UI_style(widget_t* w);
void UI_run(void);

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_HANDLES_CNEXT_CALL_TEST_H */
