#ifndef E0908_NESTED_TEST_H
#define E0908_NESTED_TEST_H

/**
 * Generated by C-Next Transpiler from: e0908-nested.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char buffer[257];

#ifdef __cplusplus
}
#endif

#endif /* E0908_NESTED_TEST_H */
