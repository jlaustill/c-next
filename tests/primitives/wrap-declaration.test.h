#ifndef WRAP_DECLARATION_TEST_H
#define WRAP_DECLARATION_TEST_H

/**
 * Generated by C-Next Transpiler from: wrap-declaration.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t byteCounter;
extern uint16_t tickCount;
extern uint32_t cycleCounter;
extern uint64_t systemTicks;

#ifdef __cplusplus
}
#endif

#endif /* WRAP_DECLARATION_TEST_H */
