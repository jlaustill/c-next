/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "transitive-mutation.test.h"

// test-transpile-only
// Issue #797: Transpiler incorrectly infers const when function delegates mutation
/* Scope: Test */

static void Test_fillData(Data& d) {
    d.value = 42U;
}

void Test_loadData(Data& d) {
    Test_fillData(d);
}
