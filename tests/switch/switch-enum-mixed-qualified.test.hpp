#ifndef SWITCH_ENUM_MIXED_QUALIFIED_TEST_H
#define SWITCH_ENUM_MIXED_QUALIFIED_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-enum-mixed-qualified.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EPriority_LOW = 0,
    EPriority_MEDIUM = 1,
    EPriority_HIGH = 2,
    EPriority_CRITICAL = 3
} EPriority;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_ENUM_MIXED_QUALIFIED_TEST_H */
