/**
 * Generated by C-Next Transpiler from: enum-scope-returns-global.test.cnx
 * A safer C for embedded systems
 */

#include "enum-scope-returns-global.test.h"

#include <stdint.h>

// test-execution
// Tests: Scope method returning global enum
/* Scope: Test */

EGlobal Test_getGlobalEnum(void) {
    return EGlobal_A;
}

int main(void) {
    EGlobal fromScope = Test_getGlobalEnum();
    if (fromScope != EGlobal_A) return 1;
    return 0;
}
