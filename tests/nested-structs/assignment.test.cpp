/**
 * Generated by C-Next Transpiler from: assignment.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-032: Nested Struct Assignment Test
// Tests: assignment to nested struct members
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

typedef struct Line {
    Point start;
    Point end;
} Line;

// Initialize
Line segment = (Line){ .start = (Point){ .x = 0, .y = 0 }, .end = (Point){ .x = 100, .y = 100 } };

void moveEndPoint(void) {
    segment.end.x = 200;
    segment.end.y = 200;
}

void setStartPoint(int32_t newX, int32_t newY) {
    segment.start.x = newX;
    segment.start.y = newY;
}
