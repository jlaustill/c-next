/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "Utils.h"

#include <stdint.h>

// Utils scope - utility functions for Display module
/* Scope: Utils */

uint8_t Utils_add(uint8_t x) {
    return x + 1;
}

uint8_t Utils_multiply(uint8_t x, uint8_t y) {
    return x * y;
}
