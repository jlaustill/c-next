#ifndef SINGLE_ARG_TEST_H
#define SINGLE_ARG_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Adafruit_MAX31856 Adafruit_MAX31856;

/* External variables */
extern const uint8_t thermoCouplePin;
extern Adafruit_MAX31856 thermocouple;

#ifdef __cplusplus
}
#endif

#endif /* SINGLE_ARG_TEST_H */
