/**
 * Generated by C-Next Transpiler from: scope-member-valid.test.cnx
 * A safer C for embedded systems
 */

#include "scope-member-valid.test.hpp"

#include <stdint.h>

// ADR-030: Valid scope member call
// Tests: calling Scope.member() works when member is defined in scope
/* Scope: LED */

void LED_on(void) {
    uint32_t x = 1U;
}

void LED_off(void) {
    uint32_t x = 0U;
}

int main(void) {
    LED_on();
    LED_off();
}
