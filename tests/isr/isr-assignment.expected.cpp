/**
 * Generated by C-Next Transpiler from: isr-assignment.test.cnx
 * A safer C for embedded systems
 */

/* ADR-040: ISR function pointer type */
typedef void (*ISR)(void);

// ADR-040: ISR assignment
// Tests: assigning handler functions to ISR variables
void handler1(void) {
}

void handler2(void) {
}

ISR currentHandler = handler1;

void switchHandler(void) {
    currentHandler = handler2;
}
