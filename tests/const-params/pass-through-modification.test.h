#ifndef PASS_THROUGH_MODIFICATION_TEST_H
#define PASS_THROUGH_MODIFICATION_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void modifiesParam(uint32_t* value);
void passesThroughToModifier(uint32_t* value);
uint32_t readOnly(const uint32_t* value);
uint32_t passesThroughToReader(const uint32_t* value);
void mixedPassThrough(uint32_t* value);
uint32_t main(void);

#ifdef __cplusplus
}
#endif

#endif /* PASS_THROUGH_MODIFICATION_TEST_H */
