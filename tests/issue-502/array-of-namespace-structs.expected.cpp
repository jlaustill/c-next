/**
 * Generated by C-Next Transpiler from: array-of-namespace-structs.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - Array of C++ namespaced structs
#include "SeaDash.hpp"

#include <stdbool.h>

// Array of C++ namespace structs
SeaDash_Parse_ParseResult results[3] = {{ .data = {0}, .count = 0, .success = false }, { .data = {1}, .count = 1, .success = true }, { .data = {2}, .count = 2, .success = true }};
