/**
 * Generated by C-Next Transpiler from: enum-this-method.test.cnx
 * A safer C for embedded systems
 */

#include "enum-this-method.test.hpp"

#include <stdint.h>
#include <stdbool.h>

// test-execution
// Tests: this.method() returning enum inside scope
/* Scope: Motor */
static Motor_EMode Motor_mode = Motor_EMode_OFF;

Motor_EMode Motor_getMode(void) {
    return Motor_mode;
}

bool Motor_test(void) {
    Motor_EMode current = Motor_getMode();
    return (current == Motor_EMode_OFF);
}

int main(void) {
    bool result = Motor_test();
    if (!result) return 1;
    return 0;
}
