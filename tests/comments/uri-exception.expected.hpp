#ifndef URI_EXCEPTION_TEST_H
#define URI_EXCEPTION_TEST_H

/**
 * Generated by C-Next Transpiler from: uri-exception.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t apiVersion;

#ifdef __cplusplus
}
#endif

#endif /* URI_EXCEPTION_TEST_H */
