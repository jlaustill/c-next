/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Helper file: Enum definition for cross-file test
typedef enum {
    EStatus_PENDING = 0,
    EStatus_ACTIVE = 1,
    EStatus_COMPLETED = 2
} EStatus;
