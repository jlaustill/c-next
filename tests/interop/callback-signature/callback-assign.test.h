#ifndef CALLBACK_ASSIGN_TEST_H
#define CALLBACK_ASSIGN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t handler_sum;

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_ASSIGN_TEST_H */
