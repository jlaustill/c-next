#ifndef SIZE_INFERENCE_TEST_H
#define SIZE_INFERENCE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t data;
extern uint16_t words;
extern int32_t nums;

#ifdef __cplusplus
}
#endif

#endif /* SIZE_INFERENCE_TEST_H */
