/**
 * Generated by C-Next Transpiler from: nested-struct-init.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - Nested struct initialization with C++ namespaced types
#include "SeaDash.hpp"

#include <stdbool.h>

typedef struct Wrapper {
    SeaDash::Parse::ParseResult result;
} Wrapper;

// This should trigger nested struct field lookup
Wrapper w = (Wrapper){ .result = (SeaDash::Parse::ParseResult){ .data = {0}, .count = 0, .success = false } };
