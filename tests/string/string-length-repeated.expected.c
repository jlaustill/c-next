/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test repeated .length usage
// TODO: Future optimization - cache strlen() when .length is used multiple times
// Current behavior: each .length generates a separate strlen() call
// Optimized behavior: generate a temp variable to cache the length
char text[65] = "Hello World";

void test(void) {
    size_t _text_len = strlen(text);
    if (_text_len > 0 && text[_text_len - 1] == 'd') {
        text[_text_len - 1] = 'D';
    }
}

