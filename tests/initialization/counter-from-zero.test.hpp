#ifndef COUNTER_FROM_ZERO_TEST_H
#define COUNTER_FROM_ZERO_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t eventCount;
extern uint32_t maxEvents;

#ifdef __cplusplus
}
#endif

#endif /* COUNTER_FROM_ZERO_TEST_H */
