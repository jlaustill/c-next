#ifndef NESTED_CRITICAL_TEST_H
#define NESTED_CRITICAL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t sharedCounter;
extern uint32_t buffer[10];
extern uint32_t writeIdx;

#ifdef __cplusplus
}
#endif

#endif /* NESTED_CRITICAL_TEST_H */
