#ifndef CONDITIONAL_COMPILATION_TEST_H
#define CONDITIONAL_COMPILATION_TEST_H

/**
 * Generated by C-Next Transpiler from: conditional-compilation.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t LED_BIT;
extern const uint32_t BLINK_DELAY;

/* Function prototypes */
void LED_on(void);
void LED_off(void);

#ifdef __cplusplus
}
#endif

#endif /* CONDITIONAL_COMPILATION_TEST_H */
