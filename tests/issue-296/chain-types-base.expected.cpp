/**
 * Generated by C-Next Transpiler from: chain-types-base.cnx
 * A safer C for embedded systems
 */

#include "chain-types-base.hpp"

// Issue #404: Base types for chained forward declaration test
// Level 1: Basic coordinate type
/* Scope: ChainTypesBase */
