#ifndef STRING_ARRAY_TEST_H
#define STRING_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char globalNames[5][33];

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_TEST_H */
