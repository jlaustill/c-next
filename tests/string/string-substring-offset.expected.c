/**
 * Generated by C-Next Transpiler from: string-substring-offset.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test substring with offset
void test(void) {
    char source[65] = "Hello, World!";
    char world[7] = "";
        strncpy(world, source + 7, 6);
        world[6] = '\0';
}
