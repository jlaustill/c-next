/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef NESTED_ANON_TEST_H
#define NESTED_ANON_TEST_H

#include "anon_types.h"

void test_nested_anon(void);
void test_nested_partial(void);

#endif // NESTED_ANON_TEST_H
