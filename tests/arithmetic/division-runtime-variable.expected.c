/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-051: Runtime variable division should compile (no static check)
void testRuntimeDivision(uint32_t divisor) {
    uint32_t result = 10U / divisor;
}
