#ifndef ENUM_ARRAY_DIMENSION_TEST_H
#define ENUM_ARRAY_DIMENSION_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-array-dimension.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "array-types.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t DATA[EColor_COUNT];

#ifdef __cplusplus
}
#endif

#endif /* ENUM_ARRAY_DIMENSION_TEST_H */
