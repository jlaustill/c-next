#ifndef LEVEL2_H
#define LEVEL2_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ELevel_LEVEL_LOW = 0,
    ELevel_LEVEL_MEDIUM = 1,
    ELevel_LEVEL_HIGH = 2
} ELevel;

#ifdef __cplusplus
}
#endif

#endif /* LEVEL2_H */
