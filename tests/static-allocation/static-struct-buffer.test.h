#ifndef STATIC_STRUCT_BUFFER_TEST_H
#define STATIC_STRUCT_BUFFER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct SensorReading {
    uint32_t timestamp;
    int16_t value;
    uint8_t sensorId;
} SensorReading;

/* External variables */
extern SensorReading readings[10];

#ifdef __cplusplus
}
#endif

#endif /* STATIC_STRUCT_BUFFER_TEST_H */
