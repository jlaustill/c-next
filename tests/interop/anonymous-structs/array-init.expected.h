/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef ARRAY_INIT_TEST_H
#define ARRAY_INIT_TEST_H

#include "anon_types.h"

void test_array_simple(void);
void test_array_display(void);

#endif // ARRAY_INIT_TEST_H
