/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "types.h"

typedef struct Config {
    EPressureType pType;
} Config;

void setDefault(Config* config) {
    config->pType = EPressureType_PRESSURE_TYPE_PSIG;
}
