/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "scope-const-bare-reference.test.h"

#include <stdint.h>

// test-execution
// Tests: const scope members referenced without this. prefix should work
// Issue #741: const variables inside scopes are referenced but never declared
/* Scope: Foo */

uint32_t Foo_getConstant(void) {
    return 42;
}

uint8_t Foo_useInExpression(void) {
    uint8_t result = 15;
    return result;
}

int main(void) {
    uint32_t val = Foo_getConstant();
    if (val != 42) return 1;
    uint8_t expr = Foo_useInExpression();
    if (expr != 15) return 2;
    return 0;
}
