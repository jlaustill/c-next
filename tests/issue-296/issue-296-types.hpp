#ifndef ISSUE_296_TYPES_H
#define ISSUE_296_TYPES_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct AppData {
    float humidity;
    float temperature;
} AppData;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_296_TYPES_H */
