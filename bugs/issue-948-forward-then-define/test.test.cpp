/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "test.test.hpp"

// test-transpile-only
// Edge case: typedef struct _foo foo; followed by struct _foo { ... };
// The type should NOT be opaque since it has a full definition.
#include "lib_with_late_def.h"

/* Scope: Draw */
static point_t Draw_origin = {};

void Draw_setup(void) {
    point_init(&Draw_origin);
}
