#ifndef MULTI_DIM_ARRAY_EXPLICIT_LENGTH_TEST_H
#define MULTI_DIM_ARRAY_EXPLICIT_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler from: multi-dim-array-explicit-length.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t matrix[8][8];

#ifdef __cplusplus
}
#endif

#endif /* MULTI_DIM_ARRAY_EXPLICIT_LENGTH_TEST_H */
