#ifndef CONST_F32_VARIABLE_TEST_H
#define CONST_F32_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: const-f32-variable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const float PI;
extern const float GRAVITY;
extern const float ZERO;

#ifdef __cplusplus
}
#endif

#endif /* CONST_F32_VARIABLE_TEST_H */
