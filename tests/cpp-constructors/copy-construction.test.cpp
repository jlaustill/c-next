/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-cpp-only
// test-execution
// Issue #924: Copy construction of C++ class instances
// When initializing from another instance, should use copy semantics
#include "CopyConstructible.hpp"

#include <stdint.h>

int main(void) {
    CopyConstructible src = {};
    src.id = 100;
    src.data = 200;
    CopyConstructible copy = src;
    if (copy.id != 100) return 1;
    if (copy.data != 200) return 2;
    copy.id = 999;
    if (src.id != 100) return 3;
    return 0;
}
