/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-047: NULL check with != operator
// Tests: checking for non-NULL before using result
#include <stdio.h>

#include <stdint.h>

void processFile(void) {
    uint8_t buffer[64] = {0};
    buffer[0] = 0;
    uint8_t result = fgets(buffer, 64, stdin);
    if (result != NULL) {
        uint8_t first = buffer[0];
    }
}
