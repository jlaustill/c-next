#ifndef BASIC_TEST_H
#define BASIC_TEST_H

/**
 * Generated by C-Next Transpiler from: basic.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint32_t counter;
extern volatile uint8_t brightness;
extern volatile uint32_t ticks;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_TEST_H */
