#ifndef MACRO_ARRAY_LOCAL_TEST_H
#define MACRO_ARRAY_LOCAL_TEST_H

/**
 * Generated by C-Next Transpiler from: macro-array-local.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint8_t Test_from_local(uint8_t idx);

#ifdef __cplusplus
}
#endif

#endif /* MACRO_ARRAY_LOCAL_TEST_H */
