/**
 * Generated by C-Next Transpiler from: e0908-guard-clause.test.cnx
 * A safer C for embedded systems
 */

// E0908: Guard clause pattern (no error)
#include <stdio.h>

void testGuardClause(void) {
    FILE* c_file = fopen("test.txt", "r");
    if (c_file == NULL) {
        return;
    }
    fclose(c_file);
}
