/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-c-only
// test-execution
// Tests: simple cross-file variable access (no struct chain) (#786 related)
#include "types.h"

#include <stdint.h>

int main(void) {
    if (COUNT != 4) return 1;
    config.items[0].padding = 42U;
    if (config.items[0U].padding != 42) return 2;
    return 0;
}
