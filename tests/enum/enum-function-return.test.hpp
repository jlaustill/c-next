#ifndef ENUM_FUNCTION_RETURN_TEST_H
#define ENUM_FUNCTION_RETURN_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-function-return.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Color_RED = 0,
    Color_GREEN = 1,
    Color_BLUE = 2,
    Color_YELLOW = 3
} Color;
typedef enum {
    TrafficLight_STOP = 0,
    TrafficLight_CAUTION = 1,
    TrafficLight_GO = 2
} TrafficLight;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_FUNCTION_RETURN_TEST_H */
