/**
 * Generated by C-Next Transpiler from: flag-define-valid.test.cnx
 * A safer C for embedded systems
 */

// ADR-037: Valid flag-only defines
// These should pass through to C unchanged
// Note: Preprocessor directives must appear at top level before declarations
#include <stdint.h>

#define ARDUINO
#define STM32F4
#define DEBUG

#include <stdint.h>

// Const values (the safe way to define constants)
extern const uint32_t LED_PIN = 13U;

extern const uint32_t ALT_PIN = 10U;

void setup(void) {
}
