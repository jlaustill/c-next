/**
 * Generated by C-Next Transpiler from: macro-array-local.test.cnx
 * A safer C for embedded systems
 */

#include "macro-array-local.test.hpp"

// test-execution
#include "fake_lib.h"

#include <stdint.h>

/* Scope: Test */

uint8_t Test_from_local(uint8_t idx) {
    msg_t msg = {0};
    fill_msg(&msg);
    return msg.data[idx];
}

int main(void) {
    uint8_t result = Test_from_local(5U);
    if (result != 6) return 1;
    return 0;
}
