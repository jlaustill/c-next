/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "this-global-test.test.h"

#include <stdint.h>

// Test: ADR-016 this. and global. keywords for explicit scope qualification
const uint8_t globalValue = 10U;

/* Scope: Motor */
static uint8_t Motor_state = 0U;

uint8_t Motor_getLocalValue(void) {
    return 5;
}

uint8_t Motor_getGlobalValue(void) {
    return globalValue;
}

uint8_t Motor_getSum(void) {
    return 5 + globalValue;
}

void Motor_setState(uint8_t val) {
    Motor_state = val;
}

int main(void) {
    Motor_setState(42U);
}
