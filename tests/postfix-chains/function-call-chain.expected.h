#ifndef FUNCTION_CALL_CHAIN_TEST_H
#define FUNCTION_CALL_CHAIN_TEST_H

/**
 * Generated by C-Next Transpiler from: function-call-chain.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct FuncCallChain_Vec3 {
    float x;
    float y;
    float z;
} FuncCallChain_Vec3;
typedef struct FuncCallChain_Transform {
    FuncCallChain_Vec3 position;
    FuncCallChain_Vec3 scale;
} FuncCallChain_Transform;

/* External variables */
extern FuncCallChain_Transform transforms[4];

#ifdef __cplusplus
}
#endif

#endif /* FUNCTION_CALL_CHAIN_TEST_H */
