#ifndef TYPEDEF_UNIQUE_TEST_H
#define TYPEDEF_UNIQUE_TEST_H

/**
 * Generated by C-Next Transpiler from: typedef-unique.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <typedef-types.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct TypedefTypes_Sensor TypedefTypes_Sensor;

/* Function prototypes */
void Reader_update(const TypedefTypes_Sensor* s);
TypedefTypes_Sensor Reader_read(void);

#ifdef __cplusplus
}
#endif

#endif /* TYPEDEF_UNIQUE_TEST_H */
