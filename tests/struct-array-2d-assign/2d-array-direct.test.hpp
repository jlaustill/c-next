#ifndef 2D_ARRAY_DIRECT_TEST_H
#define 2D_ARRAY_DIRECT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Cell {
    uint8_t row;
    uint8_t col;
    uint32_t data;
} Cell;

/* External variables */
extern Cell grid[3][4];

#ifdef __cplusplus
}
#endif

#endif /* 2D_ARRAY_DIRECT_TEST_H */
