#ifndef FILL_ALL_TEST_H
#define FILL_ALL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t buffer[100];
extern uint8_t ones[50];
extern uint16_t magic[10];
extern int32_t negatives[5];

#ifdef __cplusplus
}
#endif

#endif /* FILL_ALL_TEST_H */
