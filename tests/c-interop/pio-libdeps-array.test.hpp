#ifndef PIO_LIBDEPS_ARRAY_TEST_H
#define PIO_LIBDEPS_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler from: pio-libdeps-array.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "mock_can.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void PioArrayTest_processBuffer(const uint8_t data[8], uint8_t len);
void PioArrayTest_handleMessage(const MockCanMessage& msg);

#ifdef __cplusplus
}
#endif

#endif /* PIO_LIBDEPS_ARRAY_TEST_H */
