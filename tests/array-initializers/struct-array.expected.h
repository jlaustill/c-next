#ifndef STRUCT_ARRAY_TEST_H
#define STRUCT_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-array.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Command {
    uint8_t code;
    uint8_t len;
} Command;

/* External variables */
extern const Command commands[3];
extern Command moreCommands[2];

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_ARRAY_TEST_H */
