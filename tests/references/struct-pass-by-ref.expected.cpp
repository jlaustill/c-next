/**
 * Generated by C-Next Transpiler from: struct-pass-by-ref.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-006: Struct pass-by-reference
// Tests: struct modification persists after function call
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

void moveRight(Point& p) {
    p.x = p.x + 10;
}

int main(void) {
    Point cursor = (Point){ .x = 0, .y = 0 };
    moveRight(cursor);
}
