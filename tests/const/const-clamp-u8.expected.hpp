#ifndef CONST_CLAMP_U8_TEST_H
#define CONST_CLAMP_U8_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t MAX_VALUE;
extern const uint8_t MID_VALUE;

#ifdef __cplusplus
}
#endif

#endif /* CONST_CLAMP_U8_TEST_H */
