/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Tests: Integer modulo should work correctly (no error)
// The % operator is valid for integer types
int main(void) {
    uint32_t a = 10;
    uint32_t b = 3;
    uint32_t result = a % b;
    if (result != 1) return 1;
    int32_t c = 17;
    int32_t d = 5;
    int32_t result2 = c % d;
    if (result2 != 2) return 2;
    return 0;
}
