#ifndef CROSS_SCOPE_BITRANGE_TEST_H
#define CROSS_SCOPE_BITRANGE_TEST_H

/**
 * Generated by C-Next Transpiler from: cross-scope-bitrange.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void App_configure(void);

#ifdef __cplusplus
}
#endif

#endif /* CROSS_SCOPE_BITRANGE_TEST_H */
