#ifndef SWITCH_MULTIPLE_CASES_TEST_H
#define SWITCH_MULTIPLE_CASES_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-multiple-cases.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ECommand_READ = 0,
    ECommand_WRITE = 1,
    ECommand_PEEK = 2,
    ECommand_POKE = 3,
    ECommand_ERASE = 4
} ECommand;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_MULTIPLE_CASES_TEST_H */
