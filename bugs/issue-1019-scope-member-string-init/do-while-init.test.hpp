#ifndef DO_WHILE_INIT_TEST_H
#define DO_WHILE_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: do-while-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void S_init(void);
uint8_t S_len(void);

#ifdef __cplusplus
}
#endif

#endif /* DO_WHILE_INIT_TEST_H */
