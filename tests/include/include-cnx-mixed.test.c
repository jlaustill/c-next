/**
 * Generated by C-Next Transpiler from: include-cnx-mixed.test.cnx
 * A safer C for embedded systems
 */

// test-execution
// ADR-010: C Interoperability - Mixed includes
// Tests: Mix of .cnx, .h, and standard library includes
// cppcheck-suppress misra-c2012-21.6
#include <stdio.h>
#include <helper-types.h>
#include "helper-types.h"
#include <string.h>

#include <stdint.h>

int main(void) {
    Point p = {0};
    p.x = 10;
    HelperTypes_Color c = {0};
    c.red = 255U;
    return 0;
}
