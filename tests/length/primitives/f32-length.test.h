#ifndef F32_LENGTH_TEST_H
#define F32_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    float member;
} TestStruct;

/* External variables */
extern float globalVar;
extern float TestScope_publicMember;

/* Function prototypes */
uint32_t TestScope_getGlobalLength(void);
uint32_t TestScope_getMemberLength(void);

#ifdef __cplusplus
}
#endif

#endif /* F32_LENGTH_TEST_H */
