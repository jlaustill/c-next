/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef HELPER_TYPES_H
#define HELPER_TYPES_H

#include <stdint.h>

// Helper file with type definitions
// This file will be included by other tests
typedef struct {
    int32_t x;
    int32_t y;
} Point;

typedef struct {
    uint8_t red;
    uint8_t green;
    uint8_t blue;
} Color;

#endif // HELPER_TYPES_H

