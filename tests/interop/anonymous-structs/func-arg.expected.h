/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef FUNC_ARG_TEST_H
#define FUNC_ARG_TEST_H

#include "anon_types.h"

void test_func_arg_variable(void);
void test_func_arg_display(void);
void test_func_arg_panel(void);

#endif // FUNC_ARG_TEST_H
