/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #295: Test C++ template type value initialization
// Template types should use {} (value initialization) not = 0
// Because = 0 is invalid for non-trivial C++ class types
#include "template-stubs.h"

// Global template variable - should initialize with {}
TemplateType<Param1,Param2,Param3> globalTemplate = {};

// Single parameter template
Buffer<256,16> globalBuffer = {};

int main(void) {
    Array<Element,100> localArray = {};
}
