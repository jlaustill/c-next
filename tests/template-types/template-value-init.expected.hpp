#ifndef TEMPLATE_VALUE_INIT_TEST_H
#define TEMPLATE_VALUE_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: template-value-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* TEMPLATE_VALUE_INIT_TEST_H */
