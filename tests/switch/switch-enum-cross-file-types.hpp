#ifndef SWITCH_ENUM_CROSS_FILE_TYPES_H
#define SWITCH_ENUM_CROSS_FILE_TYPES_H

/**
 * Generated by C-Next Transpiler from: switch-enum-cross-file-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EStatus_PENDING = 0,
    EStatus_ACTIVE = 1,
    EStatus_COMPLETED = 2
} EStatus;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_ENUM_CROSS_FILE_TYPES_H */
