/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-022: Ternary with logical operators
// && and || in condition
void test(void) {
    uint32_t a = 5U;
    uint32_t b = 10U;
    uint32_t both = (a > 0U && b > 0U) ? 1U : 0U;
    uint32_t either = (a == 0U || b == 0U) ? 1U : 0U;
    uint32_t complex = (a > 0U && b > 0U || a < 0U) ? a : b;
}
