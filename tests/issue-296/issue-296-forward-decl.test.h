#ifndef ISSUE_296_FORWARD_DECL_TEST_H
#define ISSUE_296_FORWARD_DECL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct AppData AppData;

/* Function prototypes */
void DataHandler_initialize(const AppData* data);
AppData DataHandler_getData(void);
int main(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_296_FORWARD_DECL_TEST_H */
