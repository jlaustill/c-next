/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "AHandler.test.hpp"

// test-cpp-only
// Issue #580 order test: AHandler comes before ZModifier alphabetically
// Tests if file order affects const inference
#include "Config.hpp"
#include "ZModifier.hpp"

/* Scope: AHandler */

void AHandler_passThrough(Config& config) {
    ZModifier_reset(config);
}

int main(void) {
    Config c = (Config){ .value = 0U };
    AHandler_passThrough(c);
}
