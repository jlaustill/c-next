#ifndef ENUM_FUNCTION_RETURN_TEST_H
#define ENUM_FUNCTION_RETURN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Motor_EMode_OFF = 0,
    Motor_EMode_LOW = 1
} Motor_EMode;

/* Function prototypes */
Motor_EMode Motor_getMode(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_FUNCTION_RETURN_TEST_H */
