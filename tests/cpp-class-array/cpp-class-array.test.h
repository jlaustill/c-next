#ifndef CPP_CLASS_ARRAY_TEST_H
#define CPP_CLASS_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct MockDevice MockDevice;

/* External variables */
extern const uint8_t DEVICE_COUNT;
extern MockDevice devices;

/* Function prototypes */
void Test_init(void);

#ifdef __cplusplus
}
#endif

#endif /* CPP_CLASS_ARRAY_TEST_H */
