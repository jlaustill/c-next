#ifndef TYPES_H
#define TYPES_H

/**
 * Generated by C-Next Transpiler from: types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    MyEnum_A = 0,
    MyEnum_B = 1,
    MyEnum_NONE = 255
} MyEnum;

/* Struct definitions */
typedef struct CrossFileEnum_TItem {
    MyEnum assigned;
    uint8_t padding;
} CrossFileEnum_TItem;
typedef struct CrossFileEnum_Config {
    CrossFileEnum_TItem items[4];
} CrossFileEnum_Config;

/* External variables */
extern const uint8_t COUNT;
extern CrossFileEnum_Config config;

#ifdef __cplusplus
}
#endif

#endif /* TYPES_H */
