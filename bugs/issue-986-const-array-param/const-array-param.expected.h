#ifndef CONST_ARRAY_PARAM_TEST_H
#define CONST_ARRAY_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler from: const-array-param.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Handler_process(uint8_t data[8]);

#ifdef __cplusplus
}
#endif

#endif /* CONST_ARRAY_PARAM_TEST_H */
