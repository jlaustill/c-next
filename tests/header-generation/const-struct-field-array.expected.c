/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// Tests: Struct fields with const-based array dimensions in headers
const uint8_t BUFFER_SIZE = 8U;

const uint8_t ROWS = 4U;

const uint8_t COLS = 3U;

const uint8_t HEX_SIZE = 0x10U;

const uint8_t BIN_SIZE = 0b1010U;

typedef struct TData {
    uint8_t buffer[8];
    int16_t matrix[4][3];
    bool flags[16];
    uint16_t binary_arr[10];
    uint32_t literal_arr[5];
    int32_t value;
} TData;

TData data = {0};

int main(void) {
    data.buffer[0] = 1;
}
