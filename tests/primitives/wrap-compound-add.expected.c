/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Wrap with compound assignment
// Tests: wrap modifier with compound addition
uint8_t counter = 250U;

int main(void) {
    counter += 10U;
}
