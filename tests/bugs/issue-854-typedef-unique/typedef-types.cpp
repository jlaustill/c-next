/**
 * Generated by C-Next Transpiler from: typedef-types.cnx
 * A safer C for embedded systems
 */

#include "typedef-types.hpp"

// Helper: defines a struct used by the test file
/* Scope: TypedefTypes */
