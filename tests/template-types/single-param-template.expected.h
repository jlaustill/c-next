#ifndef SINGLE_PARAM_TEMPLATE_TEST_H
#define SINGLE_PARAM_TEMPLATE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Container<Element> Container<Element>;
typedef struct Vector<uint32_t> Vector<uint32_t>;

/* External variables */
extern Container<Element> singleParam;
extern Vector<uint32_t> numbers;

#ifdef __cplusplus
}
#endif

#endif /* SINGLE_PARAM_TEMPLATE_TEST_H */
