/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// URI Exception Test (ADR-043)
// Tests that :// patterns are allowed per MISRA Amendment 4
#include <stdint.h>

#include <stdint.h>

// See documentation at https://example.com/docs
// Reference: http://spec.org/standard
/* API endpoint: https://api.example.com/v1
 * Protocol: https://
 */
uint32_t apiVersion = 1;
