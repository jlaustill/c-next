#ifndef U32_ARRAY_ELEMENT_COUNT_TEST_H
#define U32_ARRAY_ELEMENT_COUNT_TEST_H

/**
 * Generated by C-Next Transpiler from: u32-array-element-count.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    uint32_t arr[16];
} TestStruct;

/* External variables */
extern uint32_t globalArr[16];
extern uint32_t TestScope_publicArr[16];

/* Function prototypes */
uint32_t TestScope_getGlobalArrayElementCount(void);
uint32_t TestScope_getScopeArrayElementCount(void);

#ifdef __cplusplus
}
#endif

#endif /* U32_ARRAY_ELEMENT_COUNT_TEST_H */
