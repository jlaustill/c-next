#ifndef NAMESPACE_STRUCT_INIT_TEST_H
#define NAMESPACE_STRUCT_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct SeaDash_Parse_ParseResult SeaDash_Parse_ParseResult;

/* External variables */
extern SeaDash_Parse_ParseResult parsed;

#ifdef __cplusplus
}
#endif

#endif /* NAMESPACE_STRUCT_INIT_TEST_H */
