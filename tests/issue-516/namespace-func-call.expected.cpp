/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "namespace-func-call.test.hpp"

// test-transpile-only
// Tests: C++ namespace function calls WITHOUT global. prefix (Issue #516)
// This test verifies that C-Next can call C++ namespaced functions
// without requiring the global. prefix
#include "CppNamespace.hpp"

/* Scope: Test */

void Test_run(void) {
    SeaDash::Parse::ParseResult result = SeaDash::Parse::parse("1,2,3", ',');
    SeaDash::Config cfg = SeaDash::getDefaultConfig();
    Deep::Level1::Level2::DeepType deep = Deep::Level1::Level2::create(42);
}
