#ifndef BOOL_ARRAY_LENGTH_TEST_H
#define BOOL_ARRAY_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    bool arr[16];
} TestStruct;

/* External variables */
extern bool globalArr[16];
extern bool TestScope_publicArr[16];

/* Function prototypes */
uint32_t TestScope_getGlobalArrayLength(void);
uint32_t TestScope_getGlobalElementLength(void);
uint32_t TestScope_getScopeArrayLength(void);
uint32_t TestScope_getScopeElementLength(void);

#ifdef __cplusplus
}
#endif

#endif /* BOOL_ARRAY_LENGTH_TEST_H */
