/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// ADR-045: String as function parameter
// Tests: passing bounded string to function
void printMessage(const char* msg) {
    uint32_t len = strlen(msg);
}

int main(void) {
    char greeting[65] = "Hello, World!";
    printMessage(&greeting);
}
