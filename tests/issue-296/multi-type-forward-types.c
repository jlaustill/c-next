/**
 * Generated by C-Next Transpiler from: multi-type-forward-types.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// Issue #404: Multiple type definitions for forward declaration tests
// Tests multiple structs and an enum used across files
typedef enum {
    EDeviceState_STATE_OFF = 0,
    EDeviceState_STATE_IDLE = 1,
    EDeviceState_STATE_ACTIVE = 2,
    EDeviceState_STATE_ERROR = 3
} EDeviceState;

typedef struct DeviceConfig {
    uint32_t baudRate;
    uint8_t address;
} DeviceConfig;

typedef struct DeviceStatus {
    EDeviceState state;
    uint32_t errorCount;
    bool connected;
} DeviceStatus;
