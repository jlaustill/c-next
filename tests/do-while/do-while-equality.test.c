/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-027: Do-while with equality condition
extern const uint8_t END_MARKER = 0xFF;

void readUntilEnd(void) {
    uint8_t byte = 0;
    do {
        byte = 0x42;
    } while (byte != END_MARKER);
}
