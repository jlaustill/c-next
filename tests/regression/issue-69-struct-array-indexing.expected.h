#ifndef ISSUE_69_STRUCT_ARRAY_INDEXING_TEST_H
#define ISSUE_69_STRUCT_ARRAY_INDEXING_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct InputData {
    uint16_t assignedSpn;
    float coeffA;
} InputData;
typedef struct Configuration {
    InputData tempInputs[8];
} Configuration;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_69_STRUCT_ARRAY_INDEXING_TEST_H */
