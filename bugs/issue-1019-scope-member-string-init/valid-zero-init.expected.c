/**
 * Generated by C-Next Transpiler from: valid-zero-init.test.cnx
 * A safer C for embedded systems
 */

#include "valid-zero-init.test.h"

#include <stdint.h>
#include <string.h>

// test-execution
// Issue #1019 Bug #2: Scope-member string should emit valid C for zero-init
// When scope-member string IS initialized before read, codegen must be valid
/* Scope: S */
static char S_buf[17] = "";

void S_init(void) {
    strncpy(S_buf, "", 16); S_buf[16] = '\0';
}

uint8_t S_len(void) {
    return strlen(S_buf);
}

int main(void) {
    S_init();
    uint8_t length = S_len();
    if (length != 0) return 1;
    return 0;
}
