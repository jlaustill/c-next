/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-execution
// ADR-010: C Interoperability - Include C-Next files
// Tests: #include <file.cnx> transpiles to #include <file.h>
#include <helper-types.hpp>

#include <stdint.h>

int main(void) {
    Point p = {0};
    p.x = 10;
    p.y = 20;
    return 0;
}
