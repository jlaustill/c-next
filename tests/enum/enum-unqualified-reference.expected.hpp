#ifndef ENUM_UNQUALIFIED_REFERENCE_TEST_H
#define ENUM_UNQUALIFIED_REFERENCE_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-unqualified-reference.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EPressureType_PRESSURE_TYPE_PSIA = 0,
    EPressureType_PRESSURE_TYPE_PSIG = 1
} EPressureType;

/* Struct definitions */
typedef struct Config {
    EPressureType pType;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_UNQUALIFIED_REFERENCE_TEST_H */
