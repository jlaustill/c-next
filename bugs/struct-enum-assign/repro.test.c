/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Minimal reproduction: assign struct enum field to local enum variable
typedef enum {
    EValueId_VALUE_A = 0,
    EValueId_VALUE_B = 1,
    EValueId_VALUE_UNASSIGNED = 255
} EValueId;

typedef struct TInput {
    EValueId assignedValue;
} TInput;

TInput input = {0};

int main(void) {
    EValueId val = input.assignedValue;
}
