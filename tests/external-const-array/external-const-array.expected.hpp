#ifndef EXTERNAL_CONST_ARRAY_TEST_H
#define EXTERNAL_CONST_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler from: external-const-array.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "config.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern bool enabled[4];

#ifdef __cplusplus
}
#endif

#endif /* EXTERNAL_CONST_ARRAY_TEST_H */
