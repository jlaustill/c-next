#ifndef STRUCT_MEMBER_TEST_H
#define STRUCT_MEMBER_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-member.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Image {
    uint32_t width;
    uint32_t height;
    uint8_t pixels[240][320];
} Image;

/* External variables */
extern Image screen;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_MEMBER_TEST_H */
