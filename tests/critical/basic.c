/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <cmsis_gcc.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_add_u32(uint32_t a, uint32_t b) {
    if (a > UINT32_MAX - b) return UINT32_MAX;
    return a + b;
}

uint8_t buffer[64] = {0};

uint32_t writeIdx = 0;

void enqueue(uint8_t* data) {
    {
        uint32_t __primask = __get_PRIMASK();
        __disable_irq();
        buffer[writeIdx] = (*data);
        writeIdx = cnx_clamp_add_u32(writeIdx, 1);
        __set_PRIMASK(__primask);
    }
}
