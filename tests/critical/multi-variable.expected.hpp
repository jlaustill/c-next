#ifndef MULTI_VARIABLE_TEST_H
#define MULTI_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t readIdx;
extern uint32_t writeIdx;
extern uint8_t buffer[64];

#ifdef __cplusplus
}
#endif

#endif /* MULTI_VARIABLE_TEST_H */
