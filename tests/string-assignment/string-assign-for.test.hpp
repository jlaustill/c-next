#ifndef STRING_ASSIGN_FOR_TEST_H
#define STRING_ASSIGN_FOR_TEST_H

/**
 * Generated by C-Next Transpiler from: string-assign-for.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char result[17];

#ifdef __cplusplus
}
#endif

#endif /* STRING_ASSIGN_FOR_TEST_H */
