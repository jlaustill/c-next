/**
 * Generated by C-Next Transpiler from: array-types.cnx
 * A safer C for embedded systems
 */

typedef enum {
    EColor_RED = 0,
    EColor_GREEN = 1,
    EColor_BLUE = 2,
    EColor_COUNT = 3
} EColor;
