#ifndef ISSUE_315_SMALL_PRIMITIVE_TEST_H
#define ISSUE_315_SMALL_PRIMITIVE_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-315-small-primitive.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <TestFuncSmall.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct ByteData {
    uint8_t value1;
    uint8_t value2;
} ByteData;

/* Function prototypes */
void ByteCaller_init(void);
uint8_t ByteCaller_test(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_315_SMALL_PRIMITIVE_TEST_H */
