/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-024: Test that bit indexing allows safe narrowing
// Using [start, width] syntax to explicitly extract bits
int main(void) {
    uint32_t large = 0xDEADBEEFU;
    uint8_t low_byte = static_cast<uint8_t>(((large >> 0U) & 0xFFU));
    uint8_t high_byte = static_cast<uint8_t>(((large >> 24U) & 0xFFU));
    uint16_t low_word = static_cast<uint16_t>(((large >> 0U) & 0xFFFFU));
}
