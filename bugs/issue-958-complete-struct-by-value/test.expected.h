#ifndef TEST_TEST_H
#define TEST_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void App_init(void);

#ifdef __cplusplus
}
#endif

#endif /* TEST_TEST_H */
