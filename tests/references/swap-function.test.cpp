/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-006: Classic swap pattern
// Tests: swap works without pointer syntax
void swap(int32_t& a, int32_t& b) {
    int32_t temp = a;
    a = b;
    b = temp;
}

int main(void) {
    int32_t x = 5;
    int32_t y = 10;
    swap(x, y);
}
