#ifndef AHANDLER_TEST_H
#define AHANDLER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"
#include "ZModifier.hpp"
#include "Config.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void AHandler_passThrough(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* AHANDLER_TEST_H */
