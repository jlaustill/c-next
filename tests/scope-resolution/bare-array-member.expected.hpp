#ifndef BARE_ARRAY_MEMBER_TEST_H
#define BARE_ARRAY_MEMBER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void ArrayBug_callback(void);
uint8_t ArrayBug_getData0(void);
bool ArrayBug_getFlag(void);

#ifdef __cplusplus
}
#endif

#endif /* BARE_ARRAY_MEMBER_TEST_H */
