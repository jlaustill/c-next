/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint16_t cnx_clamp_add_u16(uint16_t a, uint32_t b) {
    if (b > UINT16_MAX - a) return UINT16_MAX;
    return a + (uint16_t)b;
}

/* test-execution */
// For loop tests: u16 as loop counter
// Tests: u16 type can be used as for-loop counter
uint16_t main(void) {
    uint16_t sum = 0;
    for (uint16_t i = 0; i < 10; i += 1) {
        sum = cnx_clamp_add_u16(sum, i);
    }
    if (sum == 45) {
        return 0;
    }
    return 1;
}
