/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Tests: Global function returning enum
typedef enum {
    EState_OFF = 0,
    EState_ON = 1
} EState;

EState globalState = EState_OFF;

EState getState(void) {
    return globalState;
}

int main(void) {
    EState current = getState();
    if (current != EState_OFF) return 1;
    return 0;
}
