/**
 * Generated by C-Next Transpiler from: cross-file-function-call.test.cnx
 * A safer C for embedded systems
 */

// test-c-only
// test-execution
// Tests: cross-file function calls with parameter validation
#include "math-utils.h"

#include <stdint.h>

int main(void) {
    uint32_t sum = MathUtils_add(10U, 20U);
    if (sum != 30) return 1;
    uint32_t product = MathUtils_multiply(5U, 6U);
    if (product != 30) return 2;
    uint32_t combined = MathUtils_add(sum, product);
    if (combined != 60) return 3;
    return 0;
}
