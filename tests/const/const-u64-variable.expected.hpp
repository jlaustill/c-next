#ifndef CONST_U64_VARIABLE_TEST_H
#define CONST_U64_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: const-u64-variable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint64_t MAX_FILE_SIZE;
extern const uint64_t CHUNK_SIZE;

#ifdef __cplusplus
}
#endif

#endif /* CONST_U64_VARIABLE_TEST_H */
