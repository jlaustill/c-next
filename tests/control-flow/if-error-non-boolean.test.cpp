/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Coverage: Section 7.1 - if statement non-boolean condition error
// Tests: Error when using non-boolean expression as if condition
void test(void) {
    uint32_t value = 5U;
    if (value) {
        value = 10U;
    }
}
