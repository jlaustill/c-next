/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "CommandHandler.h"

#include "Config.h"

#include <stdint.h>

/* Scope: CommandHandler */

uint8_t CommandHandler_setValue(Config& cfg, uint32_t val) {
    cfg.value = val;
    return 0;
}
