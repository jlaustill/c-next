#ifndef CPP_REINTERPRET_CAST_TEST_H
#define CPP_REINTERPRET_CAST_TEST_H

/**
 * Generated by C-Next Transpiler from: cpp-reinterpret-cast.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t ByteProcessor_processBuffer(void);

#ifdef __cplusplus
}
#endif

#endif /* CPP_REINTERPRET_CAST_TEST_H */
