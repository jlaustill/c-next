#ifndef SCOPE_CONST_BARE_REFERENCE_TEST_H
#define SCOPE_CONST_BARE_REFERENCE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Foo_getConstant(void);
uint8_t Foo_useInExpression(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_CONST_BARE_REFERENCE_TEST_H */
