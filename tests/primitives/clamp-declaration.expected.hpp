#ifndef CLAMP_DECLARATION_TEST_H
#define CLAMP_DECLARATION_TEST_H

/**
 * Generated by C-Next Transpiler from: clamp-declaration.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t brightness;
extern uint16_t sensorValue;
extern uint32_t temperature;
extern const uint8_t MAX_BRIGHTNESS;

#ifdef __cplusplus
}
#endif

#endif /* CLAMP_DECLARATION_TEST_H */
