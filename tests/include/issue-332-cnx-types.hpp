#ifndef ISSUE_332_CNX_TYPES_H
#define ISSUE_332_CNX_TYPES_H

/**
 * Generated by C-Next Transpiler from: issue-332-cnx-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Issue332AppData {
    float value;
    uint32_t count;
} Issue332AppData;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_332_CNX_TYPES_H */
