#ifndef ENUM_ARRAY_SIZE_HEADER_TEST_H
#define ENUM_ARRAY_SIZE_HEADER_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-array-size-header.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EColor_RED = 0,
    EColor_GREEN = 1,
    EColor_BLUE = 2,
    EColor_COUNT = 3
} EColor;

/* External variables */
extern const uint8_t DATA[EColor_COUNT];

/* Function prototypes */
uint8_t Test_get(uint8_t idx);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_ARRAY_SIZE_HEADER_TEST_H */
