/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-024: Test that widening conversions are implicit and safe
// u8 -> u16 -> u32 -> u64 should all work without explicit casts
int main(void) {
    uint8_t byte = 255U;
    uint16_t word = byte;
    uint32_t dword = word;
    uint64_t qword = dword;
    uint64_t direct = byte;
}
