#ifndef AUTO_CONST_POINTER_TEST_H
#define AUTO_CONST_POINTER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void readOnly(const uint32_t* value);
void modified(uint32_t* value);
uint32_t mixedParams(const uint32_t* readVal, uint32_t* writeVal);
void arrayMod(uint8_t arr[4]);
uint8_t arrayReadOnly(const uint8_t arr[4]);
uint32_t main(void);

#ifdef __cplusplus
}
#endif

#endif /* AUTO_CONST_POINTER_TEST_H */
