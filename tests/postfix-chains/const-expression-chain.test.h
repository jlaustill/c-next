#ifndef CONST_EXPRESSION_CHAIN_TEST_H
#define CONST_EXPRESSION_CHAIN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Sensor {
    uint32_t id;
    uint8_t data;
} Sensor;

/* External variables */
extern const uint32_t INDEX_0;
extern const uint32_t INDEX_1;
extern const uint32_t INDEX_2;
extern const uint32_t SENSOR_COUNT;
extern const uint32_t LED_BIT;
extern const uint32_t STATUS_BIT;
extern Sensor sensors;

#ifdef __cplusplus
}
#endif

#endif /* CONST_EXPRESSION_CHAIN_TEST_H */
