/**
 * Generated by C-Next Transpiler from: basic-init.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-035: Basic Array Initialization Test
// Tests: explicit size with values
// Fixed size array with values
uint8_t data[5] = {1U, 2U, 3U, 4U, 5U};

// Different types
uint16_t words[3] = {100U, 200U, 300U};

int32_t signedNums[4] = {-1, 0, 1, 2};
