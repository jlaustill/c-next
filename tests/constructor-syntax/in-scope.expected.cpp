/**
 * Generated by C-Next Transpiler from: in-scope.test.cnx
 * A safer C for embedded systems
 */

#include "in-scope.test.hpp"

// Issue #375: Constructor inside scope
#include "constructor-stubs.h"

#include <stdint.h>

/* Scope: Sensor */
const uint8_t Sensor_pin = 10U;
Adafruit_MAX31856 Sensor_device(Sensor_pin);

void Sensor_init(void) {
}

int main(void) {
    Sensor_init();
}
