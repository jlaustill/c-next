/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "struct-no-duplication.test.h"

#include <stdint.h>

// test-execution
// Tests: Issue #369 - struct definitions should NOT be duplicated in both .h and .c files
// When generating headers, struct definitions should ONLY appear in the .h file
/* Scope: Handler */

uint8_t Handler_process(const MyData* data) {
    return data->value;
}

int main(void) {
    MyData data = {0};
    data.value = 42U;
    data.count = 1U;
    uint8_t result = Handler_process(&data);
    if (result != 42) return 1;
    return 0;
}
