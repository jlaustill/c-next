#ifndef SIMPLE_STRUCT_TEST_H
#define SIMPLE_STRUCT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Sensor {
    uint16_t id;
    float temperature;
    bool active;
} Sensor;

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_STRUCT_TEST_H */
