#ifndef ASSIGNMENT_BASIC_TEST_H
#define ASSIGNMENT_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;
extern int32_t offset;
extern bool flag;

#ifdef __cplusplus
}
#endif

#endif /* ASSIGNMENT_BASIC_TEST_H */
