/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-cpp-mode
// Tests: C++ class array initialization uses {} instead of {0}
// Bug: CppClass[4] items generated = {0} which fails for C++ classes
#include "cpp-class-array-init.h"

#include <stdint.h>

// C-Next style array of C++ class (should generate = {})
CppTestClass items[4] = {};

// C-Next style array of primitive (should still generate = {0})
uint32_t counters[8] = {0};

int main(void) {
    uint8_t dummy = 0;
}
