/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

/* ADR-040: ISR function pointer type */
typedef void (*ISR)(void);

// ADR-040: ISR array test (for vector tables)
void resetHandler(void) {
}

void nmiHandler(void) {
}

void hardFaultHandler(void) {
}

// Array of ISR pointers
ISR vectorTable[3] = {0};

void initVectors(void) {
    vectorTable[0] = resetHandler;
    vectorTable[1] = nmiHandler;
    vectorTable[2] = hardFaultHandler;
}
