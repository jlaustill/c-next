#ifndef CPP_CLASS_ARRAY_INIT_TEST_H
#define CPP_CLASS_ARRAY_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "cpp-class-array-init.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern CppTestClass items[4];
extern uint32_t counters[8];

#ifdef __cplusplus
}
#endif

#endif /* CPP_CLASS_ARRAY_INIT_TEST_H */
