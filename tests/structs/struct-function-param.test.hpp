#ifndef STRUCT_FUNCTION_PARAM_TEST_H
#define STRUCT_FUNCTION_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-function-param.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_FUNCTION_PARAM_TEST_H */
