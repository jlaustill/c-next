#ifndef HANDLER_H
#define HANDLER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.h"
#include "Storage.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Config Config;

/* Function prototypes */
uint8_t Handler_reset(Config& cfg);

#ifdef __cplusplus
}
#endif

#endif /* HANDLER_H */
