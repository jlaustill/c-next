#ifndef SIMPLE_FUNCTION_TEST_H
#define SIMPLE_FUNCTION_TEST_H

/**
 * Generated by C-Next Transpiler from: simple-function.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_FUNCTION_TEST_H */
