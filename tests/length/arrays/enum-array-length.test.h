#ifndef ENUM_ARRAY_LENGTH_TEST_H
#define ENUM_ARRAY_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    State_IDLE = 0,
    State_RUNNING = 1,
    State_ERROR = 2
} State;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_ARRAY_LENGTH_TEST_H */
