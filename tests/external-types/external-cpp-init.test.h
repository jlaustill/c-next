#ifndef EXTERNAL_CPP_INIT_TEST_H
#define EXTERNAL_CPP_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void test(void);
void main(void);

#ifdef __cplusplus
}
#endif

#endif /* EXTERNAL_CPP_INIT_TEST_H */
