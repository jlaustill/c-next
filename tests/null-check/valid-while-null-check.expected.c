/**
 * Generated by C-Next Transpiler from: valid-while-null-check.test.cnx
 * A safer C for embedded systems
 */

// ADR-046: While loop condition provides NULL check
// Tests that c_ variables checked in while condition are checked inside body
// cppcheck-suppress misra-c2012-21.6
#include <stdio.h>

#include <stdbool.h>
#include <string.h>

char line[257] = "";

bool keepReading = true;

void testWhileNullCheck(void) {
    FILE* c_file = fopen("data.txt", "r");
    while (c_file != NULL) {
        (void)fclose(c_file);
        (void)printf("File was open\n");
        c_file = fopen("nonexistent.txt", "r");
    }
}
