/**
 * Generated by C-Next Transpiler from: bare-scope-member.test.cnx
 * A safer C for embedded systems
 */

#include "bare-scope-member.test.hpp"

#include <stdint.h>

// Test bare identifier resolves to scope member
// test-execution
/* Scope: Counter */
static uint32_t Counter_value = 0U;

void Counter_increment(void) {
    Counter_value += 1U;
}

uint32_t Counter_getValue(void) {
    return Counter_value;
}

int main(void) {
    Counter_increment();
    Counter_increment();
    uint32_t result = Counter_getValue();
    if (result != 2) return 1;
    return 0;
}
