/**
 * Generated by C-Next Transpiler from: scope-struct-init.test.cnx
 * A safer C for embedded systems
 */

#include "scope-struct-init.test.h"

// test-c-only
// test-no-warnings
// Bug #992: Scope variables with struct initializers must use designated initializers
// (no compound literals at file scope) to compile on GCC 9-12
/* Scope: Origin */
Point Origin_p = { .x = 0, .y = 0 };
