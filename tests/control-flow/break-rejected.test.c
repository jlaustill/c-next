/**
 * Generated by C-Next Transpiler from: break-rejected.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-error
// Bug #1011: break is not part of C-Next — use structured conditions
void demo(void) {
    for (uint32_t i = 0; i < 10; i += 1) {
        if (i == 5) {
            break;
        }
    }
}
