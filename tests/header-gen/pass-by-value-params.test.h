#ifndef PASS_BY_VALUE_PARAMS_TEST_H
#define PASS_BY_VALUE_PARAMS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Status_Ok = 0,
    Status_Error = 1
} Status;

/* Function prototypes */
float Api_addFloats(float a, float b);
bool Api_isOk(Status status);
void Api_updateValue(uint32_t* value);
uint32_t Api_readValue(uint32_t value);

#ifdef __cplusplus
}
#endif

#endif /* PASS_BY_VALUE_PARAMS_TEST_H */
