/**
 * Generated by C-Next Transpiler from: string-basic.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test basic string declaration with initializer
char message[65] = "Hello, World!";

char name[6] = "Hello";
