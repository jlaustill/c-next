#ifndef CONST_WRAP_U8_TEST_H
#define CONST_WRAP_U8_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t FULL_CYCLE;
extern const uint8_t HALF_CYCLE;

#ifdef __cplusplus
}
#endif

#endif /* CONST_WRAP_U8_TEST_H */
