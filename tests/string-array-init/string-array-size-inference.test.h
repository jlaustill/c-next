#ifndef STRING_ARRAY_SIZE_INFERENCE_TEST_H
#define STRING_ARRAY_SIZE_INFERENCE_TEST_H

/**
 * Generated by C-Next Transpiler from: string-array-size-inference.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const char DAYS[3][17];

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_SIZE_INFERENCE_TEST_H */
