/**
 * Generated by C-Next Transpiler from: struct-declaration.test.cnx
 * A safer C for embedded systems
 */

#include "struct-declaration.test.h"

// ADR-014: Basic struct declaration
// Tests: struct definition and declaration
/* Scope: StructDecl */

int main(void) {
    Point p = {0};
    StructDecl_Color c = {0};
}
