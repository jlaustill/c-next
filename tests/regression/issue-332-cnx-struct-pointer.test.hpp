#ifndef ISSUE_332_CNX_STRUCT_POINTER_TEST_H
#define ISSUE_332_CNX_STRUCT_POINTER_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-332-cnx-struct-pointer.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <issue-332-cnx-types.hpp>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Issue332Storage_setup(void);
void Issue332Storage_processAll(void);
void Issue332Storage_initFromConfig(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_332_CNX_STRUCT_POINTER_TEST_H */
