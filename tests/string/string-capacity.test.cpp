/**
 * Generated by C-Next Transpiler from: string-capacity.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// ADR-045: Test string .capacity property (compile-time constant)
char message[65] = "Hello";

void test(void) {
    uint32_t cap = 64;
}
