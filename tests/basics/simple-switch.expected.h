#ifndef SIMPLE_SWITCH_TEST_H
#define SIMPLE_SWITCH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Color_RED = 0,
    Color_GREEN = 1,
    Color_BLUE = 2
} Color;

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_SWITCH_TEST_H */
