/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #375: Template type with constructor
#include "constructor-stubs.h"

#include <stdint.h>

const uint8_t canBus = 1;

const uint16_t rxSize = 256;

const uint16_t txSize = 16;

FlexCAN_T4<CAN1,256,16> canController(canBus);

int main(void) {
}
