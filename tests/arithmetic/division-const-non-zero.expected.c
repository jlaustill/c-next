/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-051 Phase 3: Division by const non-zero
// Should compile successfully
extern const uint32_t TEN = 10;

extern const uint32_t FIVE = 5;

void testDivisionByConstNonZero(void) {
    uint32_t result1 = 100 / TEN;
    uint32_t result2 = 25 / FIVE;
    uint32_t result3 = result1 % TEN;
}
