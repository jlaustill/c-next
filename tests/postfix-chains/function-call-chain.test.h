#ifndef FUNCTION_CALL_CHAIN_TEST_H
#define FUNCTION_CALL_CHAIN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Vec3 {
    float x;
    float y;
    float z;
} Vec3;
typedef struct Transform {
    Vec3 position;
    Vec3 scale;
} Transform;

/* External variables */
extern Transform transforms[4];

#ifdef __cplusplus
}
#endif

#endif /* FUNCTION_CALL_CHAIN_TEST_H */
