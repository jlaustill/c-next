/**
 * Generated by C-Next Transpiler from: valid-c-prefix-while-loop.test.cnx
 * A safer C for embedded systems
 */

// ADR-046: Valid c_ prefix with while loop pattern
// Tests that c_ prefixed variables work correctly in while loops.
// The while condition provides the NULL check, and reassignment is allowed.
#include <string.h>
#include <stdio.h>

#include <string.h>

char haystack[65] = "hello hello hello";

void testWhileLoop(void) {
    char* c_pos = strstr(haystack, "hello");
    while (c_pos != nullptr) {
        printf("Found at: %s\n", c_pos);
        c_pos = strstr(c_pos + 1, "hello");
    }
}
