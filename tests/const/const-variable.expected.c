/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-coverage: 1.1-u8-with-const-modifier, 1.1-u32-with-const-modifier
// ADR-013: Const variable usage
// Tests: const variable can be read but not written
extern const uint32_t MAX_SIZE = 100U;

extern const uint8_t FLAGS = 0x55U;

int main(void) {
    uint32_t size = MAX_SIZE;
    uint8_t f = FLAGS;
}
