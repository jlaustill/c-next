#ifndef TEST_H
#define TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "External.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern ExternalStruct globalExt;

/* Function prototypes */
uint8_t Test_getBroken(void);
uint8_t Test_getWorking(const ExternalStruct* ext);

#ifdef __cplusplus
}
#endif

#endif /* TEST_H */
