/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// ADR-022: Ternary with equality comparison
// Uses = for comparison (C-Next syntax)
uint32_t getValue(uint32_t x) {
    return (x == 0) ? 100 : x;
}

bool isZero(int32_t n) {
    return (n == 0) ? true : false;
}

void test(void) {
    uint32_t flag = 1U;
    uint32_t result = (flag != 0U) ? 42U : 0U;
}
