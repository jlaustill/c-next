/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #517: Designated initializers generated for external C++ classes
// C++ classes with user-defined constructors are NOT aggregate types
// Designated initializers { .field = value } don't work with them
#include "CppClass.hpp"

void test(void) {
    CppClass obj = {};
    obj.value = 42;
}

int main(void) {
    test();
}
