/**
 * Generated by C-Next Transpiler from: clamp-declaration.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Test clamp keyword in variable declarations
// Explicit clamp modifier
uint8_t brightness = 100U;

uint16_t sensorValue = 0U;

uint32_t temperature = 2500U;

// Clamp with const
extern const uint8_t MAX_BRIGHTNESS = 255U;
