/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test i32 shift beyond width - should be ERROR
// Coverage: Section 5.5-5.6 error case - shift beyond type width for signed types
void testI32ShiftBeyondWidth(void) {
    int32_t a = 1;
    int32_t bad_shift = a >> 32;
}
