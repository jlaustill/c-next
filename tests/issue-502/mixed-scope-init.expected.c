/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "mixed-scope-init.test.h"

// test-transpile-only
// Tests: Issue #502 - Mixed C-Next scopes and C++ namespaces in struct initialization
#include "SeaDash.hpp"

#include <stdbool.h>

// C-Next scope with a struct type
/* Scope: Motor */

// Wrapper combining C-Next scope type and C++ namespace type
// Initialize with both types - Motor.State should use _, SeaDash.Parse.ParseResult should use ::
MixedWrapper mw = (MixedWrapper){ .motor = (Motor_State){ .position = 0, .running = false }, .parsed = (SeaDash::Parse::ParseResult){ .data = {0}, .count = 0, .success = false } };
