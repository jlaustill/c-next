#ifndef SERIAL_H
#define SERIAL_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Serial_println(uint32_t msg);

#ifdef __cplusplus
}
#endif

#endif /* SERIAL_H */
