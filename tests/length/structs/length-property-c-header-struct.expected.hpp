#ifndef LENGTH_PROPERTY_C_HEADER_STRUCT_TEST_H
#define LENGTH_PROPERTY_C_HEADER_STRUCT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct CNextConfig {
    uint32_t magic;
    uint16_t version;
    uint8_t flags;
    uint64_t timestamp;
} CNextConfig;

#ifdef __cplusplus
}
#endif

#endif /* LENGTH_PROPERTY_C_HEADER_STRUCT_TEST_H */
