/**
 * Generated by C-Next Transpiler from: nested-struct-cast.test.cnx
 * A safer C for embedded systems
 */

// test-execution
// Issue #831: Nested struct initializer casts to parent type instead of field type
#include "nested.h"

#include <stdint.h>

int main(void) {
    outer_t val = (outer_t){ .pos = (inner_t){ .x = 10, .y = 20 }, .z = 30 };
    if (val.pos.x != 10) return 1;
    if (val.pos.y != 20) return 2;
    if (val.z != 30) return 3;
    return 0;
}
