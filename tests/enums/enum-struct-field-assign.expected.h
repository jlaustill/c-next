#ifndef ENUM_STRUCT_FIELD_ASSIGN_TEST_H
#define ENUM_STRUCT_FIELD_ASSIGN_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-struct-field-assign.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EValueId_VALUE_A = 0,
    EValueId_VALUE_B = 1,
    EValueId_VALUE_UNASSIGNED = 255
} EValueId;

/* Struct definitions */
typedef struct TInput {
    EValueId assignedValue;
} TInput;

/* External variables */
extern TInput input;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_STRUCT_FIELD_ASSIGN_TEST_H */
