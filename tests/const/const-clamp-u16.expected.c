/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// ADR-013 + ADR-044: Const clamp u16 combination
// Tests: const clamp u16 declaration and read access
extern const uint16_t MAX_ADC = 4095;

extern const uint16_t THRESHOLD = 2048;

int main(void) {
    uint16_t maxAdc = MAX_ADC;
    if (maxAdc != 4095) return 1;
    uint16_t thresh = THRESHOLD;
    if (thresh != 2048) return 2;
    if (THRESHOLD >= MAX_ADC) return 3;
    return 0;
}
