#ifndef ISSUE_322_AUTO_ADDRESS_OF_TEST_H
#define ISSUE_322_AUTO_ADDRESS_OF_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-322-auto-address-of.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void ConfigManager_initConfig(void);
void ConfigManager_loadFromStorage(void);
uint32_t ConfigManager_getTimeout(void);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_322_AUTO_ADDRESS_OF_TEST_H */
