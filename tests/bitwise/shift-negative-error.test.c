/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test negative shift amount - should be ERROR
// Coverage: Additional validation for undefined behavior
void testNegativeShift(void) {
    uint32_t a = 255;
    uint32_t bad_shift = a << -1;
}
