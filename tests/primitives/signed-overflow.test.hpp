#ifndef SIGNED_OVERFLOW_TEST_H
#define SIGNED_OVERFLOW_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int8_t small_signed;
extern int32_t large_signed;

#ifdef __cplusplus
}
#endif

#endif /* SIGNED_OVERFLOW_TEST_H */
