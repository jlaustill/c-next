/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef NESTED_STRUCT_CAST_TEST_H
#define NESTED_STRUCT_CAST_TEST_H



#endif // NESTED_STRUCT_CAST_TEST_H
