/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// ADR-044: Test all primitive types transpile correctly
// Unsigned integers
uint8_t byte = 255;

uint16_t word = 65535;

uint32_t dword = 4294967295;

uint64_t qword = 0;

// Signed integers
int8_t sbyte = -128;

int16_t sword = -32768;

int32_t sdword = -2147483648;

int64_t sqword = 0;

// Floating point
float single = 3.14;

double precise = 3.141592653589793;

// Boolean
bool flag = true;

bool ready = false;
