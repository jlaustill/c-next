/**
 * Generated by C-Next Transpiler from: chain-types-mid.cnx
 * A safer C for embedded systems
 */

// Issue #404: Mid-level types for chained forward declaration test
// Level 2: Uses Coordinate from base
#include <chain-types-base.hpp>

#include <stdint.h>

typedef struct Waypoint {
    Coordinate position;
    uint32_t id;
} Waypoint;
