#ifndef TEST_TEST_H
#define TEST_TEST_H

/**
 * Generated by C-Next Transpiler from: test.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct widget_t widget_t;

/* Function prototypes */
void App_on_change(widget_t* w);
void App_init(void);

#ifdef __cplusplus
}
#endif

#endif /* TEST_TEST_H */
