#ifndef MANAGER_H
#define MANAGER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "config.cnx"

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TReading {
    int16_t value;
    bool valid;
} TReading;

/* External variables */
extern bool enabled[DEVICE_COUNT];
extern TReading readings[DEVICE_COUNT][4];

/* Function prototypes */
void Manager_test(void);

#ifdef __cplusplus
}
#endif

#endif /* MANAGER_H */
