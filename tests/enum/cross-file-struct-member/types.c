/**
 * Generated by C-Next Transpiler from: types.cnx
 * A safer C for embedded systems
 */

#include "types.h"

#include <stdint.h>

// Helper file: enum and struct definitions for cross-file struct member test
/* Scope: CrossFileEnum */

const uint8_t COUNT = 4U;

CrossFileEnum_Config config = {0};
