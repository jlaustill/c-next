/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Issue #332: C-Next struct that will be passed to external C++ function
// This struct is defined in a C-Next file (not a C header)
// and must work with external functions expecting pointers
typedef struct Issue332AppData {
    float value;
    uint32_t count;
} Issue332AppData;
