#ifndef STRING_ARRAY_INIT_ERROR_MISMATCH_TEST_H
#define STRING_ARRAY_INIT_ERROR_MISMATCH_TEST_H

/**
 * Generated by C-Next Transpiler from: string-array-init-error-mismatch.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const char LABELS[3][11];

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_INIT_ERROR_MISMATCH_TEST_H */
