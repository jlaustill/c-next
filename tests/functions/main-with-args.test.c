/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Test: main function with command line arguments
#include <stdio.h>

#include <stdint.h>

int main(int argc, char *argv[]) {
    printf("Hello World, from %s\n", argv[0]);
    return 0;
}
