#ifndef ENUM_GLOBAL_FROM_SCOPE_TEST_H
#define ENUM_GLOBAL_FROM_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-global-from-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EGlobal_A = 0,
    EGlobal_B = 1
} EGlobal;

/* External variables */
extern EGlobal globalVar;

/* Function prototypes */
EGlobal Test_getGlobalEnum(void);
bool Test_testGlobalFunction(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_GLOBAL_FROM_SCOPE_TEST_H */
