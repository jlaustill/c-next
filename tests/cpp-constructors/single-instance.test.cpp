/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-cpp-only
// Issue #924: Single instance initialization of C++ class with constructor
// Should use field assignment pattern, not designated initializers
#include "DefaultConstructible.hpp"

#include <stdint.h>

int main(void) {
    DefaultConstructible obj = {};
    obj.value = 42;
    obj.name = "test";
    if (obj.value != 42) return 1;
    return 0;
}
