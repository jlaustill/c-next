#ifndef CONST_TYPES_H
#define CONST_TYPES_H

/**
 * Generated by C-Next Transpiler from: const-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t BYTE_CONST;
extern const uint16_t WORD_CONST;
extern const uint32_t DWORD_CONST;
extern const char STRING_CONST[17];
extern const uint8_t BYTE_ARRAY[4];
extern const char STRING_ARRAY[3][9];

#ifdef __cplusplus
}
#endif

#endif /* CONST_TYPES_H */
