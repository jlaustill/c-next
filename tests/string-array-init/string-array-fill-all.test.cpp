/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <string.h>

// test-transpile-only
// Issue #380: String array fill-all syntax
// Tests: ["value"*] expands to fill all elements
// Fill all 3 elements with "Hello" (C-style allowed for string arrays)
// cppcheck-suppress misra-c2012-9.3
// cppcheck-suppress misra-c2012-9.4
char greetings[3][11] = {"Hello", "Hello", "Hello"};

// Fill with empty string (should use {""} which C handles)
// cppcheck-suppress misra-c2012-9.3
// cppcheck-suppress misra-c2012-9.4
char empty[2][9] = {""};
