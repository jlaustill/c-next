/**
 * Generated by C-Next Transpiler from: Level2.cnx
 * A safer C for embedded systems
 */

#include "Level2.hpp"

// test-cpp-only
#include "Config.hpp"
#include "Level3.hpp"

/* Scope: Level2 */

void Level2_passToLevel3(Config& c) {
    Level3_modify(c);
}
