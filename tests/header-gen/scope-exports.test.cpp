/**
 * Generated by C-Next Transpiler from: scope-exports.test.cnx
 * A safer C for embedded systems
 */

#include "scope-exports.test.hpp"

#include <stdint.h>

// Issue #403: Scope exports header generation test
// Tests that public scope functions are exported in the header.
/* Scope: LED */
static uint8_t LED_brightness = 0U;

void LED_on(void) {
    LED_brightness = 255U;
}

void LED_off(void) {
    LED_brightness = 0U;
}

void LED_setBrightness(uint8_t level) {
    LED_brightness = level;
}

uint8_t LED_getBrightness(void) {
    return LED_brightness;
}

void LED_privateReset(void) {
    LED_brightness = 128U;
}

int main(void) {
    LED_on();
    LED_setBrightness(100U);
}
