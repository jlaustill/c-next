/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

/* test-execution */
// Issue #196 Bug 2: Array element .length should not require initialization
// Tests that accessing .length on an array element does not trigger false positive
// "use of uninitialized variable" error, since .length is a compile-time type property
int main(void) {
    uint32_t arr[4] = {0};
    if (32 != 32) {
        return 1;
    }
    uint32_t matrix[2][3] = {0};
    if (32 != 32) {
        return 2;
    }
    uint32_t partial[4] = {0};
    partial[0] = 42;
    if (32 != 32) {
        return 3;
    }
    return 0;
}
