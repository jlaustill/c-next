#ifndef COMPOUND_ASSIGN_10D_TEST_H
#define COMPOUND_ASSIGN_10D_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t hyper[2][2][2][2][2][2][2][2][2][2];

#ifdef __cplusplus
}
#endif

#endif /* COMPOUND_ASSIGN_10D_TEST_H */
