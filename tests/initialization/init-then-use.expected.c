/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: Initialize before use should be OK
int main(void) {
    uint32_t x = 0;
    x = 5U;
    uint32_t y = x + 1U;
}
