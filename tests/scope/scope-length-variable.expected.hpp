#ifndef SCOPE_LENGTH_VARIABLE_TEST_H
#define SCOPE_LENGTH_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint8_t LengthTest_getLength(void);
void LengthTest_setLength(uint8_t newLen);
uint16_t LengthTest_getOffset(void);
void LengthTest_setOffset(uint16_t newOffset);
uint16_t LengthTest_getLengthPlusOffset(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_LENGTH_VARIABLE_TEST_H */
