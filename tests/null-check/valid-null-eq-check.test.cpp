/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid NULL check using = (equality) comparison with c_ prefix
#include <stdio.h>

#include <string.h>

char buffer[65] = "";

void handleEof(void) {
    char* c_result = fgets(buffer, 65, stdin);
    if (c_result == nullptr) {
        printf("End of input\n");
    }
}
