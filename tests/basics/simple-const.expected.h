#ifndef SIMPLE_CONST_TEST_H
#define SIMPLE_CONST_TEST_H

/**
 * Generated by C-Next Transpiler from: simple-const.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t MAX_VALUE;
extern const uint8_t VERSION_MAJOR;
extern const uint8_t VERSION_MINOR;
extern const float PI;
extern const bool ENABLED;

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_CONST_TEST_H */
