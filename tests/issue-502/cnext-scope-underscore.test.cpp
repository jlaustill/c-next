/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "cnext-scope-underscore.test.h"

#include <stdbool.h>

// test-transpile-only
// Tests: Issue #502 - C-Next scope types must use _ NOT ::
// This ensures the fix doesn't incorrectly convert C-Next scope types
// C-Next scope - Motor_State should stay as Motor_State (underscore)
/* Scope: Motor */

// Another scope to test nesting
/* Scope: Sensor */

// Test: C-Next nested types must use _ not ::
Sensor_Reading reading = (Sensor_Reading){ .motorState = (Motor_State){ .position = 0, .running = false }, .value = 42 };
