/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-execution
// ADR-010: C Interoperability - Mixed includes
// Tests: Mix of .cnx, .h, and standard library includes
#include <stdio.h>
#include <helper-types.h>
#include "helper-types.h"
#include <string.h>

#include <stdint.h>

int main(void) {
    Point p = {0};
    p.x = 10;
    Color c = {0};
    c.red = 255;
    return 0;
}
