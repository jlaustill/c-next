#ifndef SCOPE_ARRAY_PARAM_TEST_H
#define SCOPE_ARRAY_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Test_writeToArray(uint8_t data[], uint8_t value);
void Test_writeAtIndex(uint8_t data[], uint32_t index, uint8_t value);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_ARRAY_PARAM_TEST_H */
