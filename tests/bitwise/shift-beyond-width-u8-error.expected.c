/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test u8 shift beyond width - should be ERROR
// Coverage: Section 5.5-5.6 error case - shift beyond type width
void testU8ShiftBeyondWidth(void) {
    uint8_t a = 1;
    uint8_t bad_shift = a << 8;
}
