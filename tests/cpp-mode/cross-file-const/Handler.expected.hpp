#ifndef HANDLER_TEST_H
#define HANDLER_TEST_H

/**
 * Generated by C-Next Transpiler from: Handler.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"
#include "Storage.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint8_t Handler_reset(Config& cfg);

#ifdef __cplusplus
}
#endif

#endif /* HANDLER_TEST_H */
