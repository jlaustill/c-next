/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid c_ prefix with cstring type
// cstring IS a nullable type, so c_ prefix is valid
#include <stdio.h>

#include <string.h>

char buffer[65] = "";

void test(void) {
    char* c_result = fgets(buffer, 65, stdin);
    if (c_result != NULL) {
        printf("Got: %s", buffer);
    }
}
