#ifndef COMPOUND_ASSIGN_BUG_TEST_H
#define COMPOUND_ASSIGN_BUG_TEST_H

/**
 * Generated by C-Next Transpiler from: compound-assign-bug.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Counter {
    int32_t value;
} Counter;

/* External variables */
extern Counter counters[2];

#ifdef __cplusplus
}
#endif

#endif /* COMPOUND_ASSIGN_BUG_TEST_H */
