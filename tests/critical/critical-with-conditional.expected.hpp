#ifndef CRITICAL_WITH_CONDITIONAL_TEST_H
#define CRITICAL_WITH_CONDITIONAL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;
extern uint32_t overflows;

#ifdef __cplusplus
}
#endif

#endif /* CRITICAL_WITH_CONDITIONAL_TEST_H */
