#ifndef MULTIPLE_EXTERNAL_ENUMS_TEST_H
#define MULTIPLE_EXTERNAL_ENUMS_TEST_H

/**
 * Generated by C-Next Transpiler from: multiple-external-enums.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "types.hpp"
#include "status.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct DeviceState {
    EPressureType pressure;
    EStatus status;
} DeviceState;

#ifdef __cplusplus
}
#endif

#endif /* MULTIPLE_EXTERNAL_ENUMS_TEST_H */
