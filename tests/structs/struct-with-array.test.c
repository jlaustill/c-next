/**
 * Generated by C-Next Transpiler from: struct-with-array.test.cnx
 * A safer C for embedded systems
 */

#include "struct-with-array.test.h"

// ADR-014: Struct with array member
// Tests: array fields inside structs
/* Scope: StructWithArray */

int main(void) {
    StructWithArray_Buffer buf = {0};
    buf.len = 0U;
    buf.data[0] = 0x41U;
    buf.data[1] = 0x42U;
    buf.len = 2U;
}
