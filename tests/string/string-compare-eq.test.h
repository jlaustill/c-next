#ifndef STRING_COMPARE_EQ_TEST_H
#define STRING_COMPARE_EQ_TEST_H

/**
 * Generated by C-Next Transpiler from: string-compare-eq.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char name[65];
extern char other[65];

#ifdef __cplusplus
}
#endif

#endif /* STRING_COMPARE_EQ_TEST_H */
