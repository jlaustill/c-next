/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid EOF check pattern for fputs using c_ prefix
#include <stdio.h>

#include <stdint.h>
#include <string.h>

char message[33] = "Hello, World!";

void writeOutput(void) {
    int32_t c_result = fputs(message, stdout);
    if (c_result != EOF) {
    }
}
