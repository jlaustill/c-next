#ifndef TESTFUNC_H
#define TESTFUNC_H

/**
 * Generated by C-Next Transpiler from: TestFunc.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
float TestFunc_addFloats(float a, float b);

#ifdef __cplusplus
}
#endif

#endif /* TESTFUNC_H */
