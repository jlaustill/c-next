/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-024: Test that signed widening conversions are implicit and safe
// i8 -> i16 -> i32 -> i64 should all work without explicit casts
int main(void) {
    int8_t sbyte = -128;
    int16_t sword = sbyte;
    int32_t sdword = sword;
    int64_t sqword = sdword;
    int64_t direct = sbyte;
}
