#ifndef SCOPE_SHARED_VARIABLE_TEST_H
#define SCOPE_SHARED_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void SharedState_increment(void);
uint32_t SharedState_getCount(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_SHARED_VARIABLE_TEST_H */
