/**
 * Generated by C-Next Transpiler from: string-compare-literal.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test string comparison with literal
char name[65] = "Alice";

void test(void) {
    if (strcmp(name, "Alice") == 0) {
    }
}
