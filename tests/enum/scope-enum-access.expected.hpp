#ifndef SCOPE_ENUM_ACCESS_TEST_H
#define SCOPE_ENUM_ACCESS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EColor_RED = 0,
    EColor_GREEN = 1,
    EColor_BLUE = 2
} EColor;

/* Function prototypes */
uint32_t Test_checkRed(EColor c);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_ENUM_ACCESS_TEST_H */
