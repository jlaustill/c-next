#ifndef TEMPLATE_TYPE_TEST_H
#define TEMPLATE_TYPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t canBus;
extern const uint16_t rxSize;
extern const uint16_t txSize;

#ifdef __cplusplus
}
#endif

#endif /* TEMPLATE_TYPE_TEST_H */
