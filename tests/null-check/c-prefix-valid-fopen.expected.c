/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid fopen with c_ prefix and NULL check
#include <stdio.h>

void processFile(void) {
    FILE c_file = fopen("data.txt", "r");
    if (c_file != NULL) {
        fclose(c_file);
    }
}
