#ifndef SIMPLE_ENUM_TEST_H
#define SIMPLE_ENUM_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Status_IDLE = 0,
    Status_RUNNING = 1,
    Status_PAUSED = 2,
    Status_STOPPED = 3
} Status;
typedef enum {
    Priority_LOW = 1,
    Priority_MEDIUM = 5,
    Priority_HIGH = 10,
    Priority_CRITICAL = 100
} Priority;

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_ENUM_TEST_H */
