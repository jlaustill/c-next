#ifndef STRUCT_WITH_ARRAY_TEST_H
#define STRUCT_WITH_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-with-array.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Buffer {
    uint8_t data[16];
    uint32_t len;
} Buffer;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_WITH_ARRAY_TEST_H */
