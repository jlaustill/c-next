#ifndef CHAIN_FORWARD_TEST_H
#define CHAIN_FORWARD_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <chain-types-mid.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Waypoint Waypoint;
typedef struct Coordinate Coordinate;

/* Function prototypes */
void Navigator_setDestination(const Waypoint* wp);
Waypoint Navigator_getDestination(void);
void Navigator_moveTo(const Coordinate* pos);
Coordinate Navigator_getCurrentPosition(void);

#ifdef __cplusplus
}
#endif

#endif /* CHAIN_FORWARD_TEST_H */
