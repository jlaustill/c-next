/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #517: Namespaced C++ class with constructor
// Test that namespaced classes with constructors also use field assignment pattern
#include "NamespacedCppClass.hpp"

void test(void) {
    TestNS::MyClass obj = {};
    obj.id = 123;
    obj.data = "test";
}

int main(void) {
    test();
}
