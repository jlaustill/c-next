#ifndef APP_H
#define APP_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t App_test(void);

#ifdef __cplusplus
}
#endif

#endif /* APP_H */
