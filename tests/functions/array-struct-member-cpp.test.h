#ifndef ARRAY_STRUCT_MEMBER_CPP_TEST_H
#define ARRAY_STRUCT_MEMBER_CPP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "array-struct-member-cpp.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern SensorReading sensors[4];

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_STRUCT_MEMBER_CPP_TEST_H */
