#ifndef TRANSITIVE_MUTATION_TEST_H
#define TRANSITIVE_MUTATION_TEST_H

/**
 * Generated by C-Next Transpiler from: transitive-mutation.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TransMutation_Data {
    uint8_t value;
} TransMutation_Data;

/* Function prototypes */
void Test_fillData(TransMutation_Data& d);
void Test_loadData(TransMutation_Data& d);

#ifdef __cplusplus
}
#endif

#endif /* TRANSITIVE_MUTATION_TEST_H */
