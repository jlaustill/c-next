#ifndef VALID_FPUTS_CHECK_TEST_H
#define VALID_FPUTS_CHECK_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char message[33];

#ifdef __cplusplus
}
#endif

#endif /* VALID_FPUTS_CHECK_TEST_H */
