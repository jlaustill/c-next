/**
 * Generated by C-Next Transpiler from: cross-scope-enum-access.test.cnx
 * A safer C for embedded systems
 */

#include "cross-scope-enum-access.test.h"

#include <stdint.h>

// test-execution
// Test: Enum access from inside a scope works without global. when unambiguous
// Issue #774: global. prefix only required when there's a naming conflict
/* Scope: Motor */

GlobalState Motor_test(void) {
    GlobalState current = GlobalState_IDLE;
    return current;
}

int main(void) {
    GlobalState result = Motor_test();
    if (result != GlobalState_IDLE) {
        return 1;
    }
    return 0;
}
