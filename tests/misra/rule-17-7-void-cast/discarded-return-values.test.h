#ifndef DISCARDED_RETURN_VALUES_TEST_H
#define DISCARDED_RETURN_VALUES_TEST_H

/**
 * Generated by C-Next Transpiler from: discarded-return-values.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Counter_next(void);
void Counter_reset(void);

#ifdef __cplusplus
}
#endif

#endif /* DISCARDED_RETURN_VALUES_TEST_H */
