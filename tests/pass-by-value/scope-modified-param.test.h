#ifndef SCOPE_MODIFIED_PARAM_TEST_H
#define SCOPE_MODIFIED_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void TestScope_increment(uint32_t& x);
uint32_t TestScope_accumulate(uint32_t& sum, uint32_t value);
void TestScope_doubleIncrement(uint32_t& x);
void TestScope_switchIncrement(uint32_t& x, uint32_t mode);
uint32_t TestScope_readOnly(uint32_t x);
uint32_t TestScope_mixedParams(uint32_t& counter, uint32_t multiplier);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_MODIFIED_PARAM_TEST_H */
