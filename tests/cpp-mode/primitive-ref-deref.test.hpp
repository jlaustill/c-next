#ifndef PRIMITIVE_REF_DEREF_TEST_H
#define PRIMITIVE_REF_DEREF_TEST_H

/**
 * Generated by C-Next Transpiler from: primitive-ref-deref.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Test_process(uint32_t& val);

#ifdef __cplusplus
}
#endif

#endif /* PRIMITIVE_REF_DEREF_TEST_H */
