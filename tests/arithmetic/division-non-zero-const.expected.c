/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-051: Division by non-zero constant should compile
extern const uint32_t TEN = 10;

void testNonZeroConst(void) {
    uint32_t result = 100 / TEN;
}
