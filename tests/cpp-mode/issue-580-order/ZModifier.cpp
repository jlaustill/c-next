/**
 * Generated by C-Next Transpiler from: ZModifier.cnx
 * A safer C for embedded systems
 */

#include "ZModifier.hpp"

// test-cpp-only
// Named with Z prefix to come AFTER AHandler alphabetically
#include "Config.hpp"

/* Scope: ZModifier */

void ZModifier_reset(Config& c) {
    c.value = 42U;
}
