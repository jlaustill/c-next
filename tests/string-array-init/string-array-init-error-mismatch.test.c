/**
 * Generated by C-Next Transpiler from: string-array-init-error-mismatch.test.cnx
 * A safer C for embedded systems
 */

// test-error: Array size mismatch
// Issue #380: String array initializers - error on size mismatch
// Declared size 3, but only 2 elements provided
// cppcheck-suppress misra-c2012-9.3
// cppcheck-suppress misra-c2012-9.4
const char LABELS[3][11] = {"One", "Two"};
