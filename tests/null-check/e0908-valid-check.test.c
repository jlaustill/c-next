/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// E0908: Valid NULL check before use (no error)
#include <stdio.h>

void testValidCheck(void) {
    FILE* c_file = fopen("test.txt", "r");
    if (c_file != NULL) {
        fclose(c_file);
    }
}
