/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint64_t cnx_clamp_add_u64(uint64_t a, uint64_t b) {
    if (b > UINT64_MAX - a) return UINT64_MAX;
    return a + (uint64_t)b;
}

/* test-execution */
// For loop tests: u64 as loop counter
// Tests: u64 type can be used as for-loop counter
int main(void) {
    uint64_t sum = 0;
    for (uint64_t i = 0; i < 10; i += 1) {
        sum = cnx_clamp_add_u64(sum, i);
    }
    if (sum == 45) {
        return 0;
    }
    return 1;
}
