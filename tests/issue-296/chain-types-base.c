/**
 * Generated by C-Next Transpiler from: chain-types-base.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Issue #404: Base types for chained forward declaration test
// Level 1: Basic coordinate type
typedef struct Coordinate {
    int32_t x;
    int32_t y;
    int32_t z;
} Coordinate;
