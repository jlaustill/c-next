/**
 * Generated by C-Next Transpiler from: stdio-suppression.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Issue #850: MISRA 21.6 suppression for stdio.h includes
// Verifies that stdio.h includes generate MISRA suppression comments
// cppcheck-suppress misra-c2012-21.6
#include <stdio.h>

void test(void) {
}
