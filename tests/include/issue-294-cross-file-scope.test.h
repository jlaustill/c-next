#ifndef ISSUE_294_CROSS_FILE_SCOPE_TEST_H
#define ISSUE_294_CROSS_FILE_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-294-cross-file-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include <issue-294-decoder.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint16_t handler_processData(const uint8_t data[8]);
uint8_t handler_extractByte(const uint8_t data[8], uint8_t idx);

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_294_CROSS_FILE_SCOPE_TEST_H */
