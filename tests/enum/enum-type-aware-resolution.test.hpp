#ifndef ENUM_TYPE_AWARE_RESOLUTION_TEST_H
#define ENUM_TYPE_AWARE_RESOLUTION_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Color_RED = 0,
    Color_GREEN = 1,
    Color_BLUE = 2
} Color;
typedef enum {
    Status_RED = 10,
    Status_YELLOW = 20,
    Status_GREEN = 30
} Status;

/* Struct definitions */
typedef struct ColorConfig {
    Color color;
} ColorConfig;
typedef struct StatusConfig {
    Status status;
} StatusConfig;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_TYPE_AWARE_RESOLUTION_TEST_H */
