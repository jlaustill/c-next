#ifndef ARRAY_OF_NAMESPACE_STRUCTS_TEST_H
#define ARRAY_OF_NAMESPACE_STRUCTS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_OF_NAMESPACE_STRUCTS_TEST_H */
