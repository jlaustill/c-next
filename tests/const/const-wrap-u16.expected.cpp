/**
 * Generated by C-Next Transpiler from: const-wrap-u16.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// ADR-013 + ADR-044: Const wrap u16 combination
// Tests: const wrap u16 declaration and read access
extern const uint16_t MAX_COUNTER = 65535U;

extern const uint16_t START_VALUE = 1000U;

int main(void) {
    uint16_t maxCnt = MAX_COUNTER;
    if (maxCnt != 65535) return 1;
    uint16_t start = START_VALUE;
    if (start != 1000) return 2;
    uint16_t diff = MAX_COUNTER - START_VALUE;
    if (diff != 64535) return 3;
    return 0;
}
