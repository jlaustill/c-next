#ifndef CNX_TESTS_REAL_LIBRARIES_FREERTOS_TASK_TYPED_TEST_H
#define CNX_TESTS_REAL_LIBRARIES_FREERTOS_TASK_TYPED_TEST_H

/**
 * Generated by C-Next Transpiler from: task-typed.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "task_types.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void counterTask_typed(TaskData* data);
void testTypedAccess(void);

#ifdef __cplusplus
}
#endif

#endif /* CNX_TESTS_REAL_LIBRARIES_FREERTOS_TASK_TYPED_TEST_H */
