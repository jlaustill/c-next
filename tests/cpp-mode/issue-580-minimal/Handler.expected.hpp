#ifndef HANDLER_TEST_H
#define HANDLER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.h"
#include "Modifier.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Config Config;

/* Function prototypes */
void Handler_passThrough(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* HANDLER_TEST_H */
