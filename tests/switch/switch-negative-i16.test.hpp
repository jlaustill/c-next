#ifndef SWITCH_NEGATIVE_I16_TEST_H
#define SWITCH_NEGATIVE_I16_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t result;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_NEGATIVE_I16_TEST_H */
