#ifndef TYPEDEF_TYPES_H
#define TYPEDEF_TYPES_H

/**
 * Generated by C-Next Transpiler from: typedef-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Sensor {
    uint32_t id;
    uint16_t value;
} Sensor;

#ifdef __cplusplus
}
#endif

#endif /* TYPEDEF_TYPES_H */
