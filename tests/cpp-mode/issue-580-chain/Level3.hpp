#ifndef LEVEL3_H
#define LEVEL3_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Level3_modify(Config& c);

#ifdef __cplusplus
}
#endif

#endif /* LEVEL3_H */
