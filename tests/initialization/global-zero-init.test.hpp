#ifndef GLOBAL_ZERO_INIT_TEST_H
#define GLOBAL_ZERO_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: global-zero-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;
extern int32_t offset;
extern bool flag;
extern uint8_t byte;

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_ZERO_INIT_TEST_H */
