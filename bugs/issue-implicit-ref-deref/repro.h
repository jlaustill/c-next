#ifndef REPRO_H
#define REPRO_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t Test_process(uint32_t& val);

#ifdef __cplusplus
}
#endif

#endif /* REPRO_H */
