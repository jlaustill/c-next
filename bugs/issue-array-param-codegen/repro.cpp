/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "repro.h"

#include <stdint.h>

// Reproducer for array param codegen mismatch between .h and .cpp
// The issue: .cpp generates correct array syntax but .h uses reference
/* Scope: CommandHandler */

void CommandHandler_process(const uint8_t data[8]) {
}

/* Scope: J1939Bus */

void J1939Bus_send(const uint8_t buffer[8]) {
}

int main(void) {
    uint8_t data[8] = {0};
    data[0] = 0x42;
    CommandHandler_process(data);
    J1939Bus_send(data);
}
