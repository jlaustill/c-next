#ifndef ATOMIC_IN_SCOPE_TEST_H
#define ATOMIC_IN_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: atomic-in-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Counter_increment(void);
void Counter_incrementBy(uint32_t delta);
void Counter_reset(void);
uint32_t Counter_get(void);
void Timer_tick(void);
void Timer_setPeriod(uint16_t p);
void Timer_adjustPeriod(uint16_t delta);

#ifdef __cplusplus
}
#endif

#endif /* ATOMIC_IN_SCOPE_TEST_H */
