#ifndef SERIALHANDLER_TEST_H
#define SERIALHANDLER_TEST_H

/**
 * Generated by C-Next Transpiler from: SerialHandler.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"
#include "CommandHandler.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void SerialHandler_handleSet(Config& config);
void SerialHandler_process(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* SERIALHANDLER_TEST_H */
