/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_add_u32(uint32_t a, uint32_t b) {
    if (a > UINT32_MAX - b) return UINT32_MAX;
    return a + b;
}

/* test-execution */
// Tests: break statement in for loop
uint32_t main(void) {
    uint32_t count = 0;
    for (uint32_t i = 0; i < 100; i = i + 1) {
        count = cnx_clamp_add_u32(count, 1);
        if (i == 9) {
            break;
        }
    }
    if (count != 10) return 1;
    return 0;
}
