/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Helper file: defines enum for external reference
typedef enum {
    EPressureType_PRESSURE_TYPE_PSIA = 0,
    EPressureType_PRESSURE_TYPE_PSIG = 1
} EPressureType;
