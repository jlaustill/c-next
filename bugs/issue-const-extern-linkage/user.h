#ifndef USER_H
#define USER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "config.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint8_t User_getMax(void);

#ifdef __cplusplus
}
#endif

#endif /* USER_H */
