#ifndef ENUM_TO_INT_CAST_TEST_H
#define ENUM_TO_INT_CAST_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Priority_LOW = 1,
    Priority_MEDIUM = 5,
    Priority_HIGH = 10,
    Priority_CRITICAL = 100
} Priority;
typedef enum {
    Flags_NONE = 0,
    Flags_READ = 1,
    Flags_WRITE = 2,
    Flags_EXECUTE = 4
} Flags;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_TO_INT_CAST_TEST_H */
