/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef MULTI_ANON_TEST_H
#define MULTI_ANON_TEST_H

#include "anon_types.h"

void test_multi_anon(void);
void test_multi_anon_partial(void);

#endif // MULTI_ANON_TEST_H
