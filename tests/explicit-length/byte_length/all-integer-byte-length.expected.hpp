#ifndef ALL_INTEGER_BYTE_LENGTH_TEST_H
#define ALL_INTEGER_BYTE_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler from: all-integer-byte-length.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t global_u8;
extern uint16_t global_u16;
extern uint32_t global_u32;
extern uint64_t global_u64;
extern int8_t global_i8;
extern int16_t global_i16;
extern int32_t global_i32;
extern int64_t global_i64;

#ifdef __cplusplus
}
#endif

#endif /* ALL_INTEGER_BYTE_LENGTH_TEST_H */
