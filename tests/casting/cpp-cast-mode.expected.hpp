#ifndef CPP_CAST_MODE_TEST_H
#define CPP_CAST_MODE_TEST_H

/**
 * Generated by C-Next Transpiler from: cpp-cast-mode.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Priority_LOW = 1,
    Priority_HIGH = 10
} Priority;

#ifdef __cplusplus
}
#endif

#endif /* CPP_CAST_MODE_TEST_H */
