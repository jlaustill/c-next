/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test u64 shift beyond width - should be ERROR
// Coverage: Section 5.5-5.6 error case - shift beyond type width
void testU64ShiftBeyondWidth(void) {
    uint64_t a = 1;
    uint64_t bad_shift = a << 64;
}
