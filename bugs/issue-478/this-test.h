#ifndef THIS_TEST_H
#define THIS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Test_ECategory_CAT_A = 0,
    Test_ECategory_CAT_B = 1
} Test_ECategory;

/* Function prototypes */
Test_ECategory Test_getCategory(void);

#ifdef __cplusplus
}
#endif

#endif /* THIS_TEST_H */
