/**
 * Generated by C-Next Transpiler from: scoped-type-array.test.cnx
 * A safer C for embedded systems
 */

#include "scoped-type-array.test.h"

#include <stdint.h>

// Test: Scoped type arrays in struct fields (Issue #1038)
// Tests this.Type[N] syntax in struct field declarations
/* Scope: Container */

// Test qualified type array from outside scope
/* Scope: User */

Container_Collection collection = {0};

User_Data userData = {0};

int main(void) {
    collection.items[0].value = 42;
    collection.items[0].flags = 0xFFU;
    collection.count = 1U;
    userData.cached[0].value = 100;
    userData.version = 1U;
    int32_t val = collection.items[0U].value;
    uint32_t cnt = collection.count;
}
