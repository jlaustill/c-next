#ifndef BASIC_TEST_H
#define BASIC_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t counter;
extern uint8_t brightness;
extern uint32_t ticks;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_TEST_H */
