#ifndef ENUM_NO_DUPLICATION_TEST_H
#define ENUM_NO_DUPLICATION_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Motor_State_IDLE = 0,
    Motor_State_RUNNING = 1,
    Motor_State_STOPPED = 2
} Motor_State;

/* External variables */
extern Motor_State Motor_current;

/* Function prototypes */
uint8_t Motor_start(void);
bool Motor_isRunning(void);
int main(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_NO_DUPLICATION_TEST_H */
