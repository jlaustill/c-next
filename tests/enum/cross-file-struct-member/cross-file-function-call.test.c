/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-c-only
// test-execution
// Tests: cross-file function calls with parameter validation
#include "math-utils.h"

#include <stdint.h>

int main(void) {
    uint32_t sum = MathUtils_add(10, 20);
    if (sum != 30) return 1;
    uint32_t product = MathUtils_multiply(5, 6);
    if (product != 30) return 2;
    uint32_t combined = MathUtils_add(sum, product);
    if (combined != 60) return 3;
    return 0;
}
