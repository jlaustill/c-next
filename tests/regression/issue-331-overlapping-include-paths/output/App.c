/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "App.h"

// Issue #331: Test file that includes Utils.cnx
// This file is used by test-issue-331.ts
#include <Utils.h>

#include <stdint.h>

/* Scope: App */

uint32_t App_test(void) {
    uint8_t result = Utils_add(5);
    if (result != 6) return 1;
    result = Utils_multiply(3, 4);
    if (result != 12) return 2;
    return 0;
}
