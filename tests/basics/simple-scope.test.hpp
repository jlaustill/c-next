#ifndef SIMPLE_SCOPE_TEST_H
#define SIMPLE_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Counter_reset(void);
void Counter_increment(void);
void Counter_add(uint32_t amount);
uint32_t Counter_get(void);
void Temperature_set(int32_t temp);
int32_t Temperature_getCelsius(void);
int32_t Temperature_getFahrenheit(void);

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_SCOPE_TEST_H */
