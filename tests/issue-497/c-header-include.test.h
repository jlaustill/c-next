#ifndef C_HEADER_INCLUDE_TEST_H
#define C_HEADER_INCLUDE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "data-types.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
Data Manager_getData(void);

#ifdef __cplusplus
}
#endif

#endif /* C_HEADER_INCLUDE_TEST_H */
