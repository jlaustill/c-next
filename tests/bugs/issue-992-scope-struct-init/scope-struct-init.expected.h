#ifndef SCOPE_STRUCT_INIT_TEST_H
#define SCOPE_STRUCT_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-struct-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

/* External variables */
extern Point Origin_p;

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_STRUCT_INIT_TEST_H */
