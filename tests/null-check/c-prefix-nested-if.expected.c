/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-046: Valid nested control flow with c_ prefix
#include <stdio.h>

#include <stdbool.h>

void nestedCheck(void) {
    FILE c_file = fopen("data.txt", "r");
    bool condition = true;
    if (condition) {
        if (c_file != NULL) {
            fclose(c_file);
        }
    }
}
