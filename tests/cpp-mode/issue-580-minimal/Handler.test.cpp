/**
 * Generated by C-Next Transpiler from: Handler.test.cnx
 * A safer C for embedded systems
 */

#include "Handler.test.hpp"

// test-cpp-only
// Issue #580 minimal reproduction: function with ONLY a pass-through call
#include "Config.hpp"
#include "Modifier.hpp"

/* Scope: Handler */

void Handler_passThrough(Config& config) {
    Modifier_reset(config);
}

int main(void) {
    Config c = (Config){ .value = 0U };
    Handler_passThrough(c);
}
