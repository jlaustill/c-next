/**
 * Generated by C-Next Transpiler from: valid-fgets-else.test.cnx
 * A safer C for embedded systems
 */

// ADR-046: Valid NULL check with else branch using c_ prefix
#include <stdio.h>

#include <string.h>

char line[129] = "";

void processLine(void) {
    char* c_result = fgets(line, 129, stdin);
    if (c_result != NULL) {
        printf("Read: %s", line);
    } else {
        printf("No more input\n");
    }
}
