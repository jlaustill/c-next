#ifndef SCOPE_REENTRANT_TEST_H
#define SCOPE_REENTRANT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t call_arg;

/* Function prototypes */
uint32_t Reentrant_inner(void);
uint32_t Reentrant_outer(uint32_t x);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_REENTRANT_TEST_H */
