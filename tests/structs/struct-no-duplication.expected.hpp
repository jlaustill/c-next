#ifndef STRUCT_NO_DUPLICATION_TEST_H
#define STRUCT_NO_DUPLICATION_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-no-duplication.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct MyData {
    uint8_t value;
    uint8_t count;
} MyData;

/* Function prototypes */
uint8_t Handler_process(const MyData& data);

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_NO_DUPLICATION_TEST_H */
