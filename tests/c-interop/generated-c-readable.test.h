#ifndef GENERATED_C_READABLE_TEST_H
#define GENERATED_C_READABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: generated-c-readable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

#ifdef __cplusplus
}
#endif

#endif /* GENERATED_C_READABLE_TEST_H */
