#ifndef STRING_BASIC_TEST_H
#define STRING_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char message[65];
extern char name[6];

#ifdef __cplusplus
}
#endif

#endif /* STRING_BASIC_TEST_H */
