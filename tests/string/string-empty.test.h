#ifndef STRING_EMPTY_TEST_H
#define STRING_EMPTY_TEST_H

/**
 * Generated by C-Next Transpiler from: string-empty.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char buffer[65];
extern char largeBuffer[257];

#ifdef __cplusplus
}
#endif

#endif /* STRING_EMPTY_TEST_H */
