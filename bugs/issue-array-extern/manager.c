/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "manager.h"

// Test: array with constant from external file
#include "config.h"

#include <stdbool.h>

bool enabled[DEVICE_COUNT] = {false, false, false, false};

TReading readings[DEVICE_COUNT][4] = {0};

/* Scope: Manager */

void Manager_test(void) {
    enabled[0] = true;
}
