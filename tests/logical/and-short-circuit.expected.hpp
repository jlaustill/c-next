#ifndef AND_SHORT_CIRCUIT_TEST_H
#define AND_SHORT_CIRCUIT_TEST_H

/**
 * Generated by C-Next Transpiler from: and-short-circuit.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t sideEffectCounter;

#ifdef __cplusplus
}
#endif

#endif /* AND_SHORT_CIRCUIT_TEST_H */
