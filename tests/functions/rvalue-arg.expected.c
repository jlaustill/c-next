/**
 * Generated by C-Next Transpiler from: rvalue-arg.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Tests: Issue #245 - rvalue expressions passed to pointer parameters
uint32_t process(uint32_t crc, uint8_t byte) {
    return crc ^ byte;
}

int main(void) {
    uint32_t value = 0x12345678U;
    uint32_t crc = 0U;
    crc = process(crc, value & 0xFFU);
    if (crc != 0x78) return 1;
    uint8_t a = 10U;
    uint8_t b = 5U;
    crc = 0U;
    crc = process(crc, a + b);
    if (crc != 15) return 2;
    return 0;
}
