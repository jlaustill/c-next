#ifndef PARAM_ARRAY_INDEXING_TEST_H
#define PARAM_ARRAY_INDEXING_TEST_H

/**
 * Generated by C-Next Transpiler from: param-array-indexing.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t result;

#ifdef __cplusplus
}
#endif

#endif /* PARAM_ARRAY_INDEXING_TEST_H */
