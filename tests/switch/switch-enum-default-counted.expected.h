#ifndef SWITCH_ENUM_DEFAULT_COUNTED_TEST_H
#define SWITCH_ENUM_DEFAULT_COUNTED_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-enum-default-counted.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EHttpStatus_OK = 0,
    EHttpStatus_CREATED = 1,
    EHttpStatus_BAD_REQUEST = 2,
    EHttpStatus_UNAUTHORIZED = 3,
    EHttpStatus_NOT_FOUND = 4
} EHttpStatus;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_ENUM_DEFAULT_COUNTED_TEST_H */
