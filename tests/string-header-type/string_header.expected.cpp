/**
 * Generated by C-Next Transpiler from: string_header.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// Test: string<N> types should generate char[N+1] in headers
// Bug #427: Headers emit string<N> instead of char[N+1]
char greeting[33] = "Hello";

// C-style allowed for string arrays (grammar limitation)
// cppcheck-suppress misra-c2012-9.3
// cppcheck-suppress misra-c2012-9.4
extern const char labels[3][17] = {"one", "two", "three"};

int main(void) {
    uint8_t len = strlen(greeting);
}
