#ifndef LEVEL2_H
#define LEVEL2_H

/**
 * Generated by C-Next Transpiler from: Level2.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"
#include "Level3.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Level2_passToLevel3(Config& c);

#ifdef __cplusplus
}
#endif

#endif /* LEVEL2_H */
