/**
 * Generated by C-Next Transpiler from: issue-294-decoder.cnx
 * A safer C for embedded systems
 */

#include "issue-294-decoder.h"

#include <stdint.h>

// Issue #294: Helper scope for cross-file scope resolution test
// This file defines a scope that will be included by another file
/* Scope: decoder */

uint16_t decoder_getSpn(const uint8_t data[8]) {
    uint16_t result = data[0U];
    result = result + (data[1U] * 256U);
    return result;
}

uint8_t decoder_getByte(const uint8_t data[8], uint8_t index) {
    return data[index];
}

uint8_t decoder_internalHelper(uint8_t val) {
    return val + 1;
}
