/**
 * Generated by C-Next Transpiler from: assignment-after-decl.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - Assignment after declaration (not just initialization)
#include "SeaDash.hpp"

#include <stdbool.h>

void test(void) {
    SeaDash::Parse::ParseResult result = {0};
    result = (SeaDash::Parse::ParseResult){ .data = {1, 2, 3}, .count = 3, .success = true };
}
