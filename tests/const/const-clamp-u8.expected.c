/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// ADR-013 + ADR-044: Const clamp u8 combination
// Tests: const clamp u8 declaration and read access
const uint8_t MAX_VALUE = 255;

const uint8_t MID_VALUE = 128;

int main(void) {
    uint8_t maxVal = MAX_VALUE;
    if (maxVal != 255) return 1;
    uint8_t midVal = MID_VALUE;
    if (midVal != 128) return 2;
    uint8_t diff = MAX_VALUE - MID_VALUE;
    if (diff != 127) return 3;
    return 0;
}
