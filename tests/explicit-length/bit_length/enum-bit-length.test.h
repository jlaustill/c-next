#ifndef ENUM_BIT_LENGTH_TEST_H
#define ENUM_BIT_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-bit-length.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Color_Red = 0,
    Color_Green = 1,
    Color_Blue = 2
} Color;
typedef enum {
    State_IDLE = 0,
    State_RUNNING = 1,
    State_STOPPED = 2
} State;

/* Struct definitions */
typedef struct TestStruct {
    State state;
} TestStruct;

/* External variables */
extern Color globalColor;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_BIT_LENGTH_TEST_H */
