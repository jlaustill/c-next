/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-014: Named field initialization
// Tests: struct initialization with named fields
typedef struct {
    int32_t x;
    int32_t y;
} Point;

void main(void) {
    Point origin = (Point){ .x = 0, .y = 0 };
    Point p = (Point){ .x = 100, .y = 200 };
}
