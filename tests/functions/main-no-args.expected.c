/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: main function with no arguments (embedded style)
int32_t main(void) {
    return 0;
}
