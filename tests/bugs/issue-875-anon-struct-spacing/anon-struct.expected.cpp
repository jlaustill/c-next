/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-cpp-only
// test-transpile-only
// Issue #875: Anonymous struct compound literal missing spaces between tokens
// When initializing an anonymous struct field, the transpiler concatenates
// tokens without spaces: "unsignedintflag_a" instead of "unsigned int flag_a"
#include "anon-struct.h"

#include <stdbool.h>

void test(void) {
    config_t cfg = (config_t){ .value = 42, .flags = { .flag_a = true } };
}
