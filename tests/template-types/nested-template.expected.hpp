#ifndef NESTED_TEMPLATE_TEST_H
#define NESTED_TEMPLATE_TEST_H

/**
 * Generated by C-Next Transpiler from: nested-template.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* NESTED_TEMPLATE_TEST_H */
