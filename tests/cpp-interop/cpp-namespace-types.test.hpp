#ifndef CPP_NAMESPACE_TYPES_TEST_H
#define CPP_NAMESPACE_TYPES_TEST_H

/**
 * Generated by C-Next Transpiler from: cpp-namespace-types.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Test_init(void);

#ifdef __cplusplus
}
#endif

#endif /* CPP_NAMESPACE_TYPES_TEST_H */
