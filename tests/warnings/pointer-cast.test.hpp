#ifndef POINTER_CAST_TEST_H
#define POINTER_CAST_TEST_H

/**
 * Generated by C-Next Transpiler from: pointer-cast.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct PtrCast_Data {
    uint32_t value;
    uint8_t flags;
} PtrCast_Data;
typedef struct PtrCast_Container {
    PtrCast_Data inner;
    uint32_t count;
} PtrCast_Container;

#ifdef __cplusplus
}
#endif

#endif /* POINTER_CAST_TEST_H */
