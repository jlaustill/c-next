#ifndef MIXED_OVERFLOW_TEST_H
#define MIXED_OVERFLOW_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint16_t safe_counter;
extern uint16_t fast_counter;
extern uint16_t default_counter;

#ifdef __cplusplus
}
#endif

#endif /* MIXED_OVERFLOW_TEST_H */
