#ifndef STATIC_STRING_BUFFER_TEST_H
#define STATIC_STRING_BUFFER_TEST_H

/**
 * Generated by C-Next Transpiler from: static-string-buffer.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char messageBuffer[65];
extern char logBuffer[129];

#ifdef __cplusplus
}
#endif

#endif /* STATIC_STRING_BUFFER_TEST_H */
