/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// test-error
// Tests: Bare enum member as function argument should error (no expectedType context)
// Issue #872: MISRA 7.2 sets expectedType for U suffix but suppressBareEnumResolution
// prevents changing this behavior without ADR approval.
typedef enum {
    Mode_OFF = 0,
    Mode_ON = 1
} Mode;

bool isOn(Mode m) {
    return m == Mode_ON;
}

int main(void) {
    bool result = isOn(Mode_ON);
    return 0;
}
