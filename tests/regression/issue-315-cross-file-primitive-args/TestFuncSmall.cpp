/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "TestFuncSmall.hpp"

#include <stdint.h>

// Issue #315: Helper scope for cross-file small primitive argument test
// This file defines a scope with u8 parameters to test SMALL_PRIMITIVE_TYPES path
/* Scope: TestFuncSmall */

uint8_t TestFuncSmall_addBytes(uint8_t a, uint8_t b) {
    return a + b;
}
