#ifndef CONST_U16_VARIABLE_TEST_H
#define CONST_U16_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: const-u16-variable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint16_t MAX_PORT;
extern const uint16_t DEFAULT_PORT;

#ifdef __cplusplus
}
#endif

#endif /* CONST_U16_VARIABLE_TEST_H */
