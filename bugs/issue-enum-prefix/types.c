/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

typedef enum {
    EPressureType_PRESSURE_TYPE_PSIA = 0,
    EPressureType_PRESSURE_TYPE_PSIG = 1
} EPressureType;
