/**
 * Generated by C-Next Transpiler from: cnext-style-array.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: C-Next style array declaration should generate correct C
// Array dimension in type position: u16[8] myArray
uint16_t myArray[8] = {};

// With initialization
uint8_t initialized[4] = {1U, 2U, 3U, 4U};

// Different types
int32_t signedArray[3] = {};

// In a function
void useArrays(void) {
    uint32_t localArray[2] = {};
    localArray[0] = 10U;
    localArray[1] = 20U;
}
