/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// ADR-023: sizeof on primitive types
int main(void) {
    uint32_t intSize = sizeof(uint32_t);
    uint32_t ptrSize = sizeof(uint64_t);
    uint32_t byteSize = sizeof(uint8_t);
    uint32_t floatSize = sizeof(float);
    uint32_t doubleSize = sizeof(double);
    uint32_t boolSize = sizeof(bool);
}
