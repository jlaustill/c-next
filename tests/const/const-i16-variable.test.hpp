#ifndef CONST_I16_VARIABLE_TEST_H
#define CONST_I16_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const int16_t MIN_ALTITUDE;
extern const int16_t MAX_ALTITUDE;
extern const int16_t SEA_LEVEL;

#ifdef __cplusplus
}
#endif

#endif /* CONST_I16_VARIABLE_TEST_H */
