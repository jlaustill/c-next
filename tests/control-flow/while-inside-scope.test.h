#ifndef WHILE_INSIDE_SCOPE_TEST_H
#define WHILE_INSIDE_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: while-inside-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t globalResult;

/* Function prototypes */
void Counter_countToFive(void);
void Counter_countWhileCondition(bool shouldCount);
uint32_t Counter_getValue(void);
void Counter_reset(void);
void Accumulator_sumRange(uint32_t limit);
uint32_t Accumulator_getSum(void);

#ifdef __cplusplus
}
#endif

#endif /* WHILE_INSIDE_SCOPE_TEST_H */
