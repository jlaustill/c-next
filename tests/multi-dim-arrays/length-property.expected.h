#ifndef LENGTH_PROPERTY_TEST_H
#define LENGTH_PROPERTY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t matrix[4][8];

#ifdef __cplusplus
}
#endif

#endif /* LENGTH_PROPERTY_TEST_H */
