/**
 * Generated by C-Next Transpiler from: helper-types.cnx
 * A safer C for embedded systems
 */

#include "helper-types.hpp"

// Helper file with type definitions
// This file will be included by other tests
/* Scope: HelperTypes */
