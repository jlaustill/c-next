#ifndef SERIALHANDLER_TEST_H
#define SERIALHANDLER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.hpp"
#include "CommandHandler.hpp"
#include "Serial.hpp"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void SerialHandler_handleReset(Config& config);
void SerialHandler_handlePreset(Config& config);
void SerialHandler_handleSave(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* SERIALHANDLER_TEST_H */
