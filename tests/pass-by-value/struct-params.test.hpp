#ifndef STRUCT_PARAMS_TEST_H
#define STRUCT_PARAMS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Counter {
    uint32_t value;
    uint32_t maxValue;
} Counter;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_PARAMS_TEST_H */
