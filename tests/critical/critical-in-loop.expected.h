#ifndef CRITICAL_IN_LOOP_TEST_H
#define CRITICAL_IN_LOOP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t sharedData[10];
extern uint32_t counter;

#ifdef __cplusplus
}
#endif

#endif /* CRITICAL_IN_LOOP_TEST_H */
