/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-036: Nested initialization syntax
uint8_t data[2][3] = {{1, 2, 3}, {4, 5, 6}};

int32_t main(void) {
    return 0;
}
