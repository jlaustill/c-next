#ifndef MIXED_SCOPE_INIT_TEST_H
#define MIXED_SCOPE_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Motor_State {
    int32_t position;
    bool running;
} Motor_State;
typedef struct MixedWrapper {
    Motor_State motor;
    SeaDash::Parse::ParseResult parsed;
} MixedWrapper;

/* External variables */
extern MixedWrapper mw;

#ifdef __cplusplus
}
#endif

#endif /* MIXED_SCOPE_INIT_TEST_H */
