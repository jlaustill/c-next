#ifndef ATOMIC_ALL_TYPES_TEST_H
#define ATOMIC_ALL_TYPES_TEST_H

/**
 * Generated by C-Next Transpiler from: atomic-all-types.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint8_t byte_counter;
extern volatile uint16_t word_counter;
extern volatile uint32_t dword_counter;

#ifdef __cplusplus
}
#endif

#endif /* ATOMIC_ALL_TYPES_TEST_H */
