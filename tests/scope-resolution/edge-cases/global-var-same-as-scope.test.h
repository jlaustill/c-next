#ifndef GLOBAL_VAR_SAME_AS_SCOPE_TEST_H
#define GLOBAL_VAR_SAME_AS_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t LED;
extern uint8_t LED_brightness;

/* Function prototypes */
void LED_on(void);
uint32_t Motor_test(void);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_VAR_SAME_AS_SCOPE_TEST_H */
