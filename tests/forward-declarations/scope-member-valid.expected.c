/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-030: Valid scope member call
// Tests: calling Scope.member() works when member is defined in scope
/* Scope: LED */

void LED_on(void) {
    uint32_t x = 1;
}

void LED_off(void) {
    uint32_t x = 0;
}

int main(void) {
    LED_on();
    LED_off();
}
