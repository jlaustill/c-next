#ifndef CONST_TABLES_TEST_H
#define CONST_TABLES_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t hexDigits;
extern const uint16_t crcTable[8];

#ifdef __cplusplus
}
#endif

#endif /* CONST_TABLES_TEST_H */
