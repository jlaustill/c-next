/**
 * Generated by C-Next Transpiler from: length-property.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-007: The .length property
// Tests: .length returns bit width for integers and element count for arrays
int main(void) {
    uint8_t byte = 0U;
    uint16_t word = 0U;
    uint32_t dword = 0U;
    uint8_t buffer[64] = {0};
    buffer[0] = 0U;
    uint32_t byteBits = 8;
    uint32_t wordBits = 16;
    uint32_t dwordBits = 32;
    uint32_t bufLen = 64;
}
