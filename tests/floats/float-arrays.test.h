#ifndef FLOAT_ARRAYS_TEST_H
#define FLOAT_ARRAYS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern float samples_f32[10];
extern double measurements_f64[5];

#ifdef __cplusplus
}
#endif

#endif /* FLOAT_ARRAYS_TEST_H */
