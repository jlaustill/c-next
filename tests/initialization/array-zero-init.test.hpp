#ifndef ARRAY_ZERO_INIT_TEST_H
#define ARRAY_ZERO_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: array-zero-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t buffer[16];
extern int32_t values[4];

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_ZERO_INIT_TEST_H */
