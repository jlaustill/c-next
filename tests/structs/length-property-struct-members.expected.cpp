/**
 * Generated by C-Next Transpiler from: length-property-struct-members.test.cnx
 * A safer C for embedded systems
 */

#include "length-property-struct-members.test.hpp"

#include <stdint.h>

// test-execution
// Regression test: .length property on struct member access
// Verifies cfg.magic.bit_length correctly returns 32 (was returning 0)
/* Scope: LengthPropMembers */

int main(void) {
    LengthPropMembers_Config cfg = {0};
    cfg.magic = 0x12345678U;
    cfg.version = 1U;
    cfg.flags = 0xFFU;
    if (32 != 32) {
        return 1;
    }
    if (16 != 16) {
        return 1;
    }
    if (8 != 8) {
        return 1;
    }
    return 0;
}
