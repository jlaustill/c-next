#ifndef ISR_IN_STRUCT_TEST_H
#define ISR_IN_STRUCT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct IsrHolder {
    ISR primary;
    ISR secondary;
} IsrHolder;

/* External variables */
extern uint32_t structCallCount;
extern uint32_t structLastHandler;

#ifdef __cplusplus
}
#endif

#endif /* ISR_IN_STRUCT_TEST_H */
