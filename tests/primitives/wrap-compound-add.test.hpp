#ifndef WRAP_COMPOUND_ADD_TEST_H
#define WRAP_COMPOUND_ADD_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t counter;

#ifdef __cplusplus
}
#endif

#endif /* WRAP_COMPOUND_ADD_TEST_H */
