#ifndef AUTO_DETECT_TEST_H
#define AUTO_DETECT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint32_t counter;

#ifdef __cplusplus
}
#endif

#endif /* AUTO_DETECT_TEST_H */
