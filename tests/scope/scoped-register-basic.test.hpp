#ifndef SCOPED_REGISTER_BASIC_TEST_H
#define SCOPED_REGISTER_BASIC_TEST_H

/**
 * Generated by C-Next Transpiler from: scoped-register-basic.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* SCOPED_REGISTER_BASIC_TEST_H */
