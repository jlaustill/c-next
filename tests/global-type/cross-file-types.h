#ifndef CROSS_FILE_TYPES_H
#define CROSS_FILE_TYPES_H

/**
 * Generated by C-Next Transpiler from: cross-file-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EPriority_LOW = 0,
    EPriority_MEDIUM = 1,
    EPriority_HIGH = 2
} EPriority;

/* Struct definitions */
typedef struct Vec2 {
    int32_t x;
    int32_t y;
} Vec2;

#ifdef __cplusplus
}
#endif

#endif /* CROSS_FILE_TYPES_H */
