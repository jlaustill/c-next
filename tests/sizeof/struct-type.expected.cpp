/**
 * Generated by C-Next Transpiler from: struct-type.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-023: sizeof on struct types
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

int main(void) {
    uint32_t pointSize = sizeof(Point);
}
