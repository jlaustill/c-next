/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-025: Counted Default Test
// Tests default(n) syntax for large enums
typedef enum {
    EHttpStatus_OK = 0,
    EHttpStatus_CREATED = 1,
    EHttpStatus_BAD_REQUEST = 2,
    EHttpStatus_UNAUTHORIZED = 3,
    EHttpStatus_NOT_FOUND = 4
} EHttpStatus;

void handleSuccess(void) {
}

void handleCreated(void) {
}

void handleOther(void) {
}

void handleStatus(EHttpStatus* status) {
    switch (status) {
        case EHttpStatus_OK: {
            handleSuccess();
            break;
        }
        case EHttpStatus_CREATED: {
            handleCreated();
            break;
        }
        default: {
            handleOther();
            break;
        }
    }
}
