/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-coverage: 267-cpp-casts
// test-execution
// Tests: C++ casts are generated when cppMode is enabled (Issue #267)
#include "cpp-cast-mode.hpp"

#include <stdint.h>

typedef enum {
    Priority_LOW = 1,
    Priority_HIGH = 10
} Priority;

int main(void) {
    uint32_t val = static_cast<uint32_t>(Priority_LOW);
    if (val != 1) return 1;
    uint32_t highVal = static_cast<uint32_t>(Priority_HIGH);
    if (highVal != 10) return 2;
    return 0;
}
