/**
 * Generated by C-Next Transpiler from: length-property-struct-members.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Regression test: .length property on struct member access
// Verifies cfg.magic.bit_length correctly returns 32 (was returning 0)
typedef struct Config {
    uint32_t magic;
    uint16_t version;
    uint8_t flags;
} Config;

int main(void) {
    Config cfg = {0};
    cfg.magic = 0x12345678U;
    cfg.version = 1U;
    cfg.flags = 0xFFU;
    if (32 != 32) {
        return 1;
    }
    if (16 != 16) {
        return 1;
    }
    if (8 != 8) {
        return 1;
    }
    return 0;
}
