#ifndef HEADER_MACRO_INCLUDE_TEST_H
#define HEADER_MACRO_INCLUDE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "config.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t devices[DEVICE_COUNT];

/* Function prototypes */
int main(void);

#ifdef __cplusplus
}
#endif

#endif /* HEADER_MACRO_INCLUDE_TEST_H */
