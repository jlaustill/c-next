/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-036: Multi-dimensional arrays in structs
typedef struct Image {
    uint32_t width;
    uint32_t height;
    uint8_t pixels[240][320];
} Image;

Image screen = {0};

int main(void) {
    screen.width = 320U;
    screen.height = 240U;
    screen.pixels[0][0] = 0U;
    screen.pixels[239][319] = 255U;
    return 0;
}
