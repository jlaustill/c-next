/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "namespace-init.test.h"

#include <stdint.h>

// Test: Initialization tracking with scopes (ADR-016)
uint8_t globalCount = 0;

// Global - uninitialized
/* Scope: Counter */
static uint8_t Counter_count = 0;

void Counter_init(void) {
    Counter_count = 0U;
}

void Counter_increment(void) {
    Counter_count = Counter_count + 1U;
}

int main(void) {
    Counter_init();
    Counter_increment();
}
