/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "cross-scope-access.test.h"

#include <stdint.h>

// Test cross-scope access without global. prefix
// test-execution
/* Scope: LED */
static uint8_t LED_brightness = 100;

void LED_setBrightness(uint8_t level) {
    LED_brightness = level;
}

uint8_t LED_getBrightness(void) {
    return LED_brightness;
}

/* Scope: Motor */

void Motor_adjustLED(void) {
    LED_setBrightness(50);
}

int main(void) {
    Motor_adjustLED();
    uint8_t brightness = LED_getBrightness();
    if (brightness != 50) return 1;
    return 0;
}
