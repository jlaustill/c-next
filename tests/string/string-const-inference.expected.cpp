/**
 * Generated by C-Next Transpiler from: string-const-inference.test.cnx
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test const string capacity inference from literal
extern const char VERSION[6] = "1.0.0";

extern const char APP_NAME[6] = "MyApp";
