#ifndef TERNARY_IN_EXPRESSIONS_TEST_H
#define TERNARY_IN_EXPRESSIONS_TEST_H

/**
 * Generated by C-Next Transpiler from: ternary-in-expressions.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t result;

#ifdef __cplusplus
}
#endif

#endif /* TERNARY_IN_EXPRESSIONS_TEST_H */
