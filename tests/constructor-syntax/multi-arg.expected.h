#ifndef MULTI_ARG_TEST_H
#define MULTI_ARG_TEST_H

/**
 * Generated by C-Next Transpiler from: multi-arg.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "constructor-stubs.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t csPin;
extern const uint8_t diPin;
extern const uint8_t doPin;
extern const uint8_t clkPin;
extern Adafruit_MAX31856 thermocouple;

#ifdef __cplusplus
}
#endif

#endif /* MULTI_ARG_TEST_H */
