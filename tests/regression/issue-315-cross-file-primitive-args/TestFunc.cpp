/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "TestFunc.hpp"

#include <stdint.h>

// Issue #315: Helper scope for cross-file primitive argument test
// This file defines a scope with f32 parameters
/* Scope: TestFunc */

float TestFunc_addFloats(float a, float b) {
    return a + b;
}
