/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// test-error
// Tests: Bare enum member as function argument should error (no expectedType)
typedef enum {
    Mode_OFF = 0,
    Mode_ON = 1
} Mode;

bool isOn(Mode m) {
    return m == Mode_ON;
}

int main(void) {
    bool result = isOn(Mode_ON);
    return 0;
}
