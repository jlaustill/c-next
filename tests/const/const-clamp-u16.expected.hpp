#ifndef CONST_CLAMP_U16_TEST_H
#define CONST_CLAMP_U16_TEST_H

/**
 * Generated by C-Next Transpiler from: const-clamp-u16.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint16_t MAX_ADC;
extern const uint16_t THRESHOLD;

#ifdef __cplusplus
}
#endif

#endif /* CONST_CLAMP_U16_TEST_H */
