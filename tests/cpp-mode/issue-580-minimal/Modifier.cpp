/**
 * Generated by C-Next Transpiler from: Modifier.cnx
 * A safer C for embedded systems
 */

#include "Modifier.hpp"

// test-cpp-only
#include "Config.hpp"

/* Scope: Modifier */

void Modifier_reset(Config& c) {
    c.value = 42U;
}
