/**
 * Generated by C-Next Transpiler from: cross-file-enum-global-prefix.test.cnx
 * A safer C for embedded systems
 */

// test-c-only
// test-execution
// Tests: cross-file enum assignment WITH global. prefix (#786 workaround)
#include "types.h"

#include <stdint.h>

int main(void) {
    config.items[0].assigned = MyEnum_A;
    MyEnum val = config.items[0U].assigned;
    if (val != MyEnum_A) return 1;
    return 0;
}
