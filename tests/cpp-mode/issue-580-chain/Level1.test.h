#ifndef LEVEL1_TEST_H
#define LEVEL1_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "Config.h"
#include "Level2.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Level1_entry(Config& config);

#ifdef __cplusplus
}
#endif

#endif /* LEVEL1_TEST_H */
