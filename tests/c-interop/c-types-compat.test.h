#ifndef C_TYPES_COMPAT_TEST_H
#define C_TYPES_COMPAT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t byte;
extern uint16_t word;
extern uint32_t dword;
extern int8_t sbyte;
extern int16_t sword;
extern int32_t sdword;
extern float single;
extern double double_val;
extern bool flag;

#ifdef __cplusplus
}
#endif

#endif /* C_TYPES_COMPAT_TEST_H */
