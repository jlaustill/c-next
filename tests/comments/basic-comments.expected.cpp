/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Basic Comments Test (ADR-043)
// Tests that line comments are preserved in output
#include <stdint.h>

#include <stdint.h>

// Global variable with comment
uint32_t counter = 0;

/* Block comment
 * spanning multiple lines
 * should be preserved
 */
uint32_t maxValue = 100;

// Function with inline comment
uint32_t increment(uint32_t value) {
    return value + 1;
}
