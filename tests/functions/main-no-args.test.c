/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: main function with no arguments (embedded style)
int main(void) {
    return 0;
}
