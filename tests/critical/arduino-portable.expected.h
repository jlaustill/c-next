#ifndef ARDUINO_PORTABLE_TEST_H
#define ARDUINO_PORTABLE_TEST_H

/**
 * Generated by C-Next Transpiler from: arduino-portable.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void CriticalTest_safeWrite(uint8_t newValue);

#ifdef __cplusplus
}
#endif

#endif /* ARDUINO_PORTABLE_TEST_H */
