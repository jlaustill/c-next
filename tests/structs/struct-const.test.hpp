#ifndef STRUCT_CONST_TEST_H
#define STRUCT_CONST_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

/* External variables */
extern const Point ORIGIN;
extern const Point UNIT;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_CONST_TEST_H */
