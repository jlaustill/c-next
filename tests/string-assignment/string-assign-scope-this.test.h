#ifndef STRING_ASSIGN_SCOPE_THIS_TEST_H
#define STRING_ASSIGN_SCOPE_THIS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char Logger_message[65];

/* Function prototypes */
void Logger_setMessage(void);
void Logger_clear(void);
void Logger_setCustom(void);

#ifdef __cplusplus
}
#endif

#endif /* STRING_ASSIGN_SCOPE_THIS_TEST_H */
