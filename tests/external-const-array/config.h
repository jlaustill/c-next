#ifndef CONFIG_H
#define CONFIG_H

/**
 * Generated by C-Next Transpiler from: config.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t DEVICE_COUNT;

#ifdef __cplusplus
}
#endif

#endif /* CONFIG_H */
