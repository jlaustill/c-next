#ifndef MATH_UTILS_H
#define MATH_UTILS_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t MathUtils_add(uint32_t a, uint32_t b);
uint32_t MathUtils_multiply(uint32_t a, uint32_t b);

#ifdef __cplusplus
}
#endif

#endif /* MATH_UTILS_H */
