/**
 * Generated by C-Next Transpiler from: level1.cnx
 * A safer C for embedded systems
 */

#include "level1.hpp"

// Middle level - includes level2 and uses its enum
#include "level2.hpp"

/* Scope: NestedExtEnum */

void setMedium(NestedExtEnum_Config& cfg) {
    cfg.level = ELevel_LEVEL_MEDIUM;
}
