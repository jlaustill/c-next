#ifndef ASSIGNMENT_TEST_H
#define ASSIGNMENT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Line {
    Point start;
    Point end;
} Line;

/* External variables */
extern Line segment;

#ifdef __cplusplus
}
#endif

#endif /* ASSIGNMENT_TEST_H */
