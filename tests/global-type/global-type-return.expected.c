/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "global-type-return.test.h"

#include <stdint.h>

// test-execution
// Tests: global.EnumType as function return type inside scope
// Issue #478: global.EnumType not recognized as type reference inside scope
// Define enum in same file to avoid cross-file header conflicts
/* Scope: TestScope */

ETestCategory TestScope_getCategory(void) {
    return ETestCategory_TEST_CAT_B;
}

int main(void) {
    int32_t catValue = (int32_t)TestScope_getCategory();
    if (catValue != 1) return 1;
    return 0;
}
