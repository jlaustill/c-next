/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-execution
// Tests: Cross-file enum value used as array dimension gets correct prefix
#include "array-types.h"

#include <stdint.h>

extern const uint8_t DATA[EColor_COUNT] = {10U, 20U, 30U};

int main(void) {
    if (DATA[0U] != 10) return 1;
    if (DATA[1U] != 20) return 2;
    if (DATA[2U] != 30) return 3;
    return 0;
}
