#ifndef STRUCT_ARRAY_2D_ASSIGN_TEST_H
#define STRUCT_ARRAY_2D_ASSIGN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TReading {
    int16_t value;
    uint32_t timestamp;
    bool valid;
} TReading;

/* External variables */
extern TReading readings[4][4];

/* Function prototypes */
uint32_t Test_run(void);
int main(void);

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_ARRAY_2D_ASSIGN_TEST_H */
