#ifndef SCOPE_CALL_NO_AUTO_CONST_TEST_H
#define SCOPE_CALL_NO_AUTO_CONST_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-call-no-auto-const.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct AppConfig {
    uint32_t value;
    bool enabled;
} AppConfig;

/* Function prototypes */
void Storage_load(AppConfig& config);
void Storage_save(const AppConfig& config);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_CALL_NO_AUTO_CONST_TEST_H */
