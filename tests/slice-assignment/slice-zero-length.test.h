#ifndef SLICE_ZERO_LENGTH_TEST_H
#define SLICE_ZERO_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
u32 main();

#ifdef __cplusplus
}
#endif

#endif /* SLICE_ZERO_LENGTH_TEST_H */
