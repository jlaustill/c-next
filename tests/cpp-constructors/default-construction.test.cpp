/**
 * Generated by C-Next Transpiler from: default-construction.test.cnx
 * A safer C for embedded systems
 */

// test-cpp-only
// test-execution
// Issue #924: Default construction of C++ class arrays
// Arrays of classes with constructors should default-construct each element
#include "DefaultConstructible.hpp"

#include <stdint.h>

int main(void) {
    DefaultConstructible arr[3] = {};
    arr[0].value = 10;
    arr[1].value = 20;
    arr[2].value = 30;
    if (arr[0U].value != 10) return 1;
    if (arr[1U].value != 20) return 2;
    if (arr[2U].value != 30) return 3;
    return 0;
}
