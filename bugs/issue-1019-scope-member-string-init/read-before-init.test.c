/**
 * Generated by C-Next Transpiler from: read-before-init.test.cnx
 * A safer C for embedded systems
 */

#include "read-before-init.test.h"

#include <stdint.h>
#include <string.h>

// test-error
// Issue #1019 Bug #1: Use-before-init for scope members should be caught
// Reading a scope-member string before initialization should produce E0381
/* Scope: S */
static char S_buf[17] = 0;

uint8_t S_first(void) {
    return S_buf[0U];
}

int main(void) {
    uint8_t c = S_first();
    return c;
}
