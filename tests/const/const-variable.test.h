#ifndef CONST_VARIABLE_TEST_H
#define CONST_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t MAX_SIZE;
extern const uint8_t FLAGS;

#ifdef __cplusplus
}
#endif

#endif /* CONST_VARIABLE_TEST_H */
