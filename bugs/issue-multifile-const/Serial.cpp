/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "Serial.h"

#include "Config.h"
#include "Handler.h"

/* Scope: Serial */

static void Serial_handleReset(Config& config) {
    Handler_reset(config);
}

void Serial_process(Config& config) {
    Serial_handleReset(config);
}
