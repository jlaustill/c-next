/**
 * Generated by C-Next Transpiler from: struct-array.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-035: Struct Array Initialization Test
// Tests: array of structs with initializers
typedef struct Command {
    uint8_t code;
    uint8_t len;
} Command;

// Array of structs with explicit size
const Command commands[3] = {(Command){ .code = 0x01U, .len = 4U }, (Command){ .code = 0x02U, .len = 8U }, (Command){ .code = 0x03U, .len = 2U }};

// Array of structs with size inference
Command moreCommands[2] = {(Command){ .code = 0x10U, .len = 1U }, (Command){ .code = 0x20U, .len = 2U }};
