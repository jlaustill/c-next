#ifndef NESTED_STRUCT_ARRAYS_TEST_H
#define NESTED_STRUCT_ARRAYS_TEST_H

/**
 * Generated by C-Next Transpiler from: nested-struct-arrays.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Coordinate {
    int32_t x;
    int32_t y;
} Coordinate;
typedef struct Path {
    Coordinate points[4];
    uint32_t count;
} Path;
typedef struct Route {
    Path segments[2];
    uint32_t totalSegments;
} Route;

#ifdef __cplusplus
}
#endif

#endif /* NESTED_STRUCT_ARRAYS_TEST_H */
