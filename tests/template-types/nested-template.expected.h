#ifndef NESTED_TEMPLATE_TEST_H
#define NESTED_TEMPLATE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct Container<Pair<Element,Element>> Container<Pair<Element,Element>>;
typedef struct Vector<Container<Element>> Vector<Container<Element>>;

/* External variables */
extern Container<Pair<Element,Element>> nestedPair;
extern Vector<Container<Element>> vectorOfContainers;

#ifdef __cplusplus
}
#endif

#endif /* NESTED_TEMPLATE_TEST_H */
