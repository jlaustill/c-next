#ifndef SCOPE_BIT_SINGLE_WRITE_TEST_H
#define SCOPE_BIT_SINGLE_WRITE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Flags_setReady(void);
void Flags_clearReady(void);
void Flags_setError(void);
uint8_t Flags_getStatus(void);
void Flags_reset(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_BIT_SINGLE_WRITE_TEST_H */
