/**
 * Generated by C-Next Transpiler from: level2.cnx
 * A safer C for embedded systems
 */

// Deepest level - defines the enum
typedef enum {
    ELevel_LEVEL_LOW = 0,
    ELevel_LEVEL_MEDIUM = 1,
    ELevel_LEVEL_HIGH = 2
} ELevel;
