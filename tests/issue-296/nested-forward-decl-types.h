#ifndef NESTED_FORWARD_DECL_TYPES_H
#define NESTED_FORWARD_DECL_TYPES_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Vector2D {
    float x;
    float y;
} Vector2D;
typedef struct BoundingBox {
    Vector2D min;
    Vector2D max;
} BoundingBox;

#ifdef __cplusplus
}
#endif

#endif /* NESTED_FORWARD_DECL_TYPES_H */
