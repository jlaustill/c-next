#ifndef CRITICAL_IN_IF_TEST_H
#define CRITICAL_IN_IF_TEST_H

/**
 * Generated by C-Next Transpiler from: critical-in-if.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t sharedValue;
extern bool flag;

#ifdef __cplusplus
}
#endif

#endif /* CRITICAL_IN_IF_TEST_H */
