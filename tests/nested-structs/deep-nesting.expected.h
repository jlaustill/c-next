#ifndef DEEP_NESTING_TEST_H
#define DEEP_NESTING_TEST_H

/**
 * Generated by C-Next Transpiler from: deep-nesting.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Color {
    uint8_t r;
    uint8_t g;
    uint8_t b;
} Color;
typedef struct Material {
    Color ambient;
    Color diffuse;
    Color specular;
    float shininess;
} Material;
typedef struct Mesh {
    Material material;
    uint32_t vertexCount;
} Mesh;

/* External variables */
extern Mesh cube;

#ifdef __cplusplus
}
#endif

#endif /* DEEP_NESTING_TEST_H */
