/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-014: Const struct
// Tests: constant struct declaration
typedef struct {
    int32_t x;
    int32_t y;
} Point;

const Point ORIGIN = (Point){ .x = 0, .y = 0 };

const Point UNIT = (Point){ .x = 1, .y = 1 };

void main(void) {
    int32_t x = ORIGIN.x;
    int32_t y = UNIT.y;
}
