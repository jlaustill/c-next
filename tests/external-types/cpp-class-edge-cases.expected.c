/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Issue #517: C++ class edge cases
// Tests various edge cases for C++ class struct initialization
#include "CppTestClass.hpp"

void test(void) {
    CppTestClass localMulti = {};
    localMulti.value = 50;
    localMulti.name = "local";
    CppTestClass localSingle = {};
    localSingle.value = 42;
    CppTestClass obj = {};
    obj.value = 10;
    obj.name = "updated";
}

int main(void) {
    test();
}
