#ifndef U8_MULTI_DIM_TEST_H
#define U8_MULTI_DIM_TEST_H

/**
 * Generated by C-Next Transpiler from: u8-multi-dim.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t matrix2d[4][8];
extern uint8_t cube3d[2][3][4];

#ifdef __cplusplus
}
#endif

#endif /* U8_MULTI_DIM_TEST_H */
