#ifndef ARRAY_MEMBER_INIT_TEST_H
#define ARRAY_MEMBER_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: array-member-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    uint8_t flags[4];
    uint32_t version;
} Config;
typedef struct Packet {
    uint8_t header[4];
    uint8_t payload[8];
    uint32_t checksum;
} Packet;

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_MEMBER_INIT_TEST_H */
