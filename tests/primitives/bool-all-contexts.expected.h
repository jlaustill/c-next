#ifndef BOOL_ALL_CONTEXTS_TEST_H
#define BOOL_ALL_CONTEXTS_TEST_H

/**
 * Generated by C-Next Transpiler from: bool-all-contexts.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Flags {
    bool enabled;
    bool active;
} Flags;

/* External variables */
extern bool globalTrue;
extern bool globalFalse;
extern bool flagArray[4];

#ifdef __cplusplus
}
#endif

#endif /* BOOL_ALL_CONTEXTS_TEST_H */
