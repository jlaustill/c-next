/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test basic string concatenation
void test(void) {
    char first[33] = "Hello";
    char second[33] = " World";
    char result[65] = "";
        strncpy(result, first, 64);
        strncat(result, second, 64 - strlen(result));
        result[64] = '\0';
}
