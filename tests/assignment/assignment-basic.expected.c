/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

/* test-execution */
// ADR-001: Basic assignment operator
// Tests: <- operator transpiles to = in C
uint32_t counter = 0;

int32_t offset = -10;

bool flag = true;

void updateValues(void) {
    counter = 42;
    offset = 100;
    flag = false;
}

uint32_t main(void) {
    updateValues();
    if (counter == 42 && offset == 100 && flag == false) {
        return 0;
    }
    return 1;
}
