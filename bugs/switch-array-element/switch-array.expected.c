/**
 * Generated by C-Next Transpiler from: switch-array.test.cnx
 * A safer C for embedded systems
 */

#include "switch-array.test.h"

#include <stdint.h>

// Bug: switch on array element rejected as "boolean type"
/* Scope: Test */

void Test_working(void) {
    uint8_t x = 1U;
    switch (x) {
        case 1: {
            break;
        }
        default: {
            break;
        }
    }
}

void Test_failing(void) {
    uint8_t data[4] = {1U, 2U, 3U, 4U};
    switch (data[0U]) {
        case 1: {
            break;
        }
        default: {
            break;
        }
    }
}
