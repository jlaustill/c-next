/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

void deep(void) {
    uint32_t x = 1;
}
