#ifndef ENUM_BARE_IN_FUNCTION_ARG_TEST_H
#define ENUM_BARE_IN_FUNCTION_ARG_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Mode_OFF = 0,
    Mode_ON = 1
} Mode;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_BARE_IN_FUNCTION_ARG_TEST_H */
