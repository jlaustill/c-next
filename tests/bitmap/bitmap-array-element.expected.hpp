#ifndef BITMAP_ARRAY_ELEMENT_TEST_H
#define BITMAP_ARRAY_ELEMENT_TEST_H

/**
 * Generated by C-Next Transpiler from: bitmap-array-element.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Bitmaps */
/* Bitmap: StatusFlags
 *   active: bit 0
 *   ready: bit 1
 *   error: bit 2
 *   mode: bits 3-5 (3 bits)
 *   priority: bits 6-7 (2 bits)
 */
typedef uint8_t StatusFlags;

#ifdef __cplusplus
}
#endif

#endif /* BITMAP_ARRAY_ELEMENT_TEST_H */
