#ifndef NULL_IN_WHILE_TEST_H
#define NULL_IN_WHILE_TEST_H

/**
 * Generated by C-Next Transpiler from: null-in-while.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char buffer[65];

#ifdef __cplusplus
}
#endif

#endif /* NULL_IN_WHILE_TEST_H */
