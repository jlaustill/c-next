#ifndef HEADER_MACRO_INCLUDE_TEST_H
#define HEADER_MACRO_INCLUDE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t devices[DEVICE_COUNT];

#ifdef __cplusplus
}
#endif

#endif /* HEADER_MACRO_INCLUDE_TEST_H */
