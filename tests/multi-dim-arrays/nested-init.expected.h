#ifndef NESTED_INIT_TEST_H
#define NESTED_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: nested-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t data[2][3];

#ifdef __cplusplus
}
#endif

#endif /* NESTED_INIT_TEST_H */
