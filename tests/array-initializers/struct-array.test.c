/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-035: Struct Array Initialization Test
// Tests: array of structs with initializers
typedef struct Command {
    uint8_t code;
    uint8_t len;
} Command;

// Array of structs with explicit size
extern const Command commands[3] = {(Command){ .code = 0x01, .len = 4 }, (Command){ .code = 0x02, .len = 8 }, (Command){ .code = 0x03, .len = 2 }};

// Array of structs with size inference
Command moreCommands[2] = {(Command){ .code = 0x10, .len = 1 }, (Command){ .code = 0x20, .len = 2 }};
