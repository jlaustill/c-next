/**
 * Generated by C-Next Transpiler from: u8-array-param-sized.test.cnx
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Tests: Issue #368 variant - u8 array with explicit size
// Function with explicit array size (like the working u32 test)
void writeToSized(uint8_t arr[8], uint32_t index, uint8_t value) {
    arr[index] = value;
}

int main(void) {
    uint8_t buffer[8] = {0};
    buffer[0] = 0U;
    writeToSized(buffer, 0U, 42U);
    if (buffer[0U] != 42) return 1;
    return 0;
}
