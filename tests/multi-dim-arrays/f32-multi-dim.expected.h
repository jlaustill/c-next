#ifndef F32_MULTI_DIM_TEST_H
#define F32_MULTI_DIM_TEST_H

/**
 * Generated by C-Next Transpiler from: f32-multi-dim.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern float matrix2d[4][8];
extern float cube3d[2][3][4];

#ifdef __cplusplus
}
#endif

#endif /* F32_MULTI_DIM_TEST_H */
