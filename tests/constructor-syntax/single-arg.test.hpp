#ifndef SINGLE_ARG_TEST_H
#define SINGLE_ARG_TEST_H

/**
 * Generated by C-Next Transpiler from: single-arg.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "constructor-stubs.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t thermoCouplePin;
extern Adafruit_MAX31856 thermocouple;

#ifdef __cplusplus
}
#endif

#endif /* SINGLE_ARG_TEST_H */
