/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test that const zero detection does NOT apply to floats
// Float division by zero is well-defined (produces infinity or NaN)
void test_const_zero_float(void) {
    const float ZERO = 0.0;
    const double ZERO_D = 0.0;
    float result_f = 10.0 / ZERO;
    double result_d = 100.0 / ZERO_D;
    result_f = ZERO / ZERO;
    result_d = ZERO_D / ZERO_D;
}

void main(void) {
    test_const_zero_float();
}
