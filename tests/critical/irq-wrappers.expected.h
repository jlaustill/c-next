#ifndef IRQ_WRAPPERS_TEST_H
#define IRQ_WRAPPERS_TEST_H

/**
 * Generated by C-Next Transpiler from: irq-wrappers.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t buffer[64];
extern uint32_t writeIdx;

#ifdef __cplusplus
}
#endif

#endif /* IRQ_WRAPPERS_TEST_H */
