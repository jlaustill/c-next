#ifndef CONFIG_H
#define CONFIG_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ECategory_CAT_A = 0,
    ECategory_CAT_B = 1
} ECategory;

#ifdef __cplusplus
}
#endif

#endif /* CONFIG_H */
