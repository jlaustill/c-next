#ifndef STRING_ARRAY_INIT_TEST_H
#define STRING_ARRAY_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const char LABELS[3][11];
extern char colors[4][9];

/* Function prototypes */
void Test_init(void);

#ifdef __cplusplus
}
#endif

#endif /* STRING_ARRAY_INIT_TEST_H */
