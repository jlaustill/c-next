#ifndef REGISTER_WO_OPERATIONS_TEST_H
#define REGISTER_WO_OPERATIONS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t LED_BIT;
extern const uint32_t BUTTON_BIT;
extern uint32_t dynamicBit;

#ifdef __cplusplus
}
#endif

#endif /* REGISTER_WO_OPERATIONS_TEST_H */
