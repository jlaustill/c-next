#ifndef ARRAY_MEMBER_ACCESS_TEST_H
#define ARRAY_MEMBER_ACCESS_TEST_H

/**
 * Generated by C-Next Transpiler from: array-member-access.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Item {
    uint32_t value;
    uint8_t flags;
} Item;
typedef struct Container {
    Item items[3];
} Container;

#ifdef __cplusplus
}
#endif

#endif /* ARRAY_MEMBER_ACCESS_TEST_H */
