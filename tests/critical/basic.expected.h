#ifndef BASIC_TEST_H
#define BASIC_TEST_H

/**
 * Generated by C-Next Transpiler from: basic.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t buffer[64];
extern uint32_t writeIdx;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_TEST_H */
