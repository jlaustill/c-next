#ifndef CONST_I64_VARIABLE_TEST_H
#define CONST_I64_VARIABLE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const int64_t MIN_TIMESTAMP;
extern const int64_t MAX_TIMESTAMP;
extern const int64_t EPOCH;

#ifdef __cplusplus
}
#endif

#endif /* CONST_I64_VARIABLE_TEST_H */
