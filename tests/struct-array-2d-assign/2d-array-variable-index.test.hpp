#ifndef 2D_ARRAY_VARIABLE_INDEX_TEST_H
#define 2D_ARRAY_VARIABLE_INDEX_TEST_H

/**
 * Generated by C-Next Transpiler from: 2d-array-variable-index.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Pixel {
    uint8_t r;
    uint8_t g;
    uint8_t b;
} Pixel;

/* External variables */
extern Pixel image[4][4];

#ifdef __cplusplus
}
#endif

#endif /* 2D_ARRAY_VARIABLE_INDEX_TEST_H */
