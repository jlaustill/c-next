/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-030: Valid define-before-use
// Tests: function defined before it's called compiles successfully
void helper(void) {
}

int main(void) {
    helper();
}
