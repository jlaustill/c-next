/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

/* ADR-040: ISR function pointer type */
typedef void (*ISR)(void);

// ADR-040: Basic ISR type test
// ISR is a built-in type for void(void) function pointers
void timerHandler(void) {
}

void uartHandler(void) {
}

// Use ISR as parameter type
void registerHandler(ISR handler) {
}

// Use ISR as struct field
typedef struct {
    ISR timerCallback;
    ISR uartCallback;
} InterruptController;
