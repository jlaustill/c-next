/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "callback-header.test.h"

// test-transpile-only
// Issue #914: Public scope function matching callback typedef
// The header prototype must have pointer params matching the .c implementation
// Specifically tests that primitive params (u8) get pointer syntax in headers
#include "widget.h"

#include <stdint.h>

/* Scope: Renderer */

void Renderer_flush(widget_t* w, const rect_t* area, uint8_t* buf) {
}

void Renderer_init(void) {
    widget_t* w = widget_create();
    widget_set_flush_cb(w, Renderer_flush);
}
