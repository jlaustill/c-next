/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-036: 3D array declaration
uint8_t voxels[4][4][4] = {0};

void init(void) {
    voxels[0][0][0] = 1;
    voxels[3][3][3] = 255;
}

int main(void) {
    init();
    return 0;
}
