#ifndef GLOBAL_EXTERNAL_STRUCT_ARRAY_TEST_H
#define GLOBAL_EXTERNAL_STRUCT_ARRAY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "External.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern ExternalStruct globalExt;

/* Function prototypes */
uint8_t Test_getFromGlobal(void);
uint8_t Test_getFromParam(const ExternalStruct& ext);
uint8_t Test_getCount(void);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_EXTERNAL_STRUCT_ARRAY_TEST_H */
