/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-004: Basic register declaration and access
// Tests: standalone register definition outside of scope
/* Register: GPIO @ 0x40000000 */
#define GPIO_DR (*(volatile uint32_t*)(0x40000000 + 0x00))
#define GPIO_PSR (*(volatile uint32_t const *)(0x40000000 + 0x08))

void main(void) {
    GPIO_DR = 0xFF;
    uint32_t status = GPIO_PSR;
    uint32_t data = GPIO_DR;
}
