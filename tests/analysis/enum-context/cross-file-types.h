#ifndef CROSS_FILE_TYPES_H
#define CROSS_FILE_TYPES_H

/**
 * Generated by C-Next Transpiler from: cross-file-types.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    ESpnCategory_SPN_CAT_TEMPERATURE = 0,
    ESpnCategory_SPN_CAT_PRESSURE = 1,
    ESpnCategory_SPN_CAT_UNKNOWN = 2
} ESpnCategory;

#ifdef __cplusplus
}
#endif

#endif /* CROSS_FILE_TYPES_H */
