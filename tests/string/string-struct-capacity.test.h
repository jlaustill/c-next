#ifndef STRING_STRUCT_CAPACITY_TEST_H
#define STRING_STRUCT_CAPACITY_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Person {
    char name[65][65];
    char bio[129][129];
    uint32_t age;
} Person;
typedef struct Config {
    char key[33][33];
    char value[257][257];
} Config;

#ifdef __cplusplus
}
#endif

#endif /* STRING_STRUCT_CAPACITY_TEST_H */
