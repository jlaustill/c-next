#ifndef CNEXT_SCOPE_STILL_WORKS_TEST_H
#define CNEXT_SCOPE_STILL_WORKS_TEST_H

/**
 * Generated by C-Next Transpiler from: cnext-scope-still-works.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t Motor_speed;

/* Function prototypes */
void Motor_start(void);
void Motor_stop(void);
void Controller_run(void);

#ifdef __cplusplus
}
#endif

#endif /* CNEXT_SCOPE_STILL_WORKS_TEST_H */
