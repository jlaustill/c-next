#ifndef F64_ALL_CONTEXTS_TEST_H
#define F64_ALL_CONTEXTS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Vector {
    double x;
    double y;
    double z;
} Vector;

/* External variables */
extern double global_d;
extern double global_uninit;
extern double measurements[8];

#ifdef __cplusplus
}
#endif

#endif /* F64_ALL_CONTEXTS_TEST_H */
