#ifndef REGISTER_U64_FIELD_TEST_H
#define REGISTER_U64_FIELD_TEST_H

/**
 * Generated by C-Next Transpiler from: register-u64-field.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* REGISTER_U64_FIELD_TEST_H */
