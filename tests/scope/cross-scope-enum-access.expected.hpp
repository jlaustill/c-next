#ifndef CROSS_SCOPE_ENUM_ACCESS_TEST_H
#define CROSS_SCOPE_ENUM_ACCESS_TEST_H

/**
 * Generated by C-Next Transpiler from: cross-scope-enum-access.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    GlobalState_IDLE = 0,
    GlobalState_RUNNING = 1,
    GlobalState_STOPPED = 2
} GlobalState;

/* Function prototypes */
GlobalState Motor_test(void);

#ifdef __cplusplus
}
#endif

#endif /* CROSS_SCOPE_ENUM_ACCESS_TEST_H */
