/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "Handler.h"

#include "Config.h"
#include "Storage.h"

#include <stdint.h>

/* Scope: Handler */

uint8_t Handler_reset(Config& cfg) {
    Storage_loadDefaults(cfg);
    return 0;
}
