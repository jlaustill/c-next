#ifndef SCOPE_BIT_RANGE_WRITE_TEST_H
#define SCOPE_BIT_RANGE_WRITE_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-bit-range-write.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Sensor_setLowByte(uint8_t byte);
void Sensor_setHighNibble(uint8_t nibble);
uint16_t Sensor_getValue(void);
void Sensor_reset(uint16_t v);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_BIT_RANGE_WRITE_TEST_H */
