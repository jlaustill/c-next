#ifndef SIMPLE_TEMPLATE_TEST_H
#define SIMPLE_TEMPLATE_TEST_H

/**
 * Generated by C-Next Transpiler from: simple-template.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* SIMPLE_TEMPLATE_TEST_H */
