/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-013: Const function parameter
// Tests: const parameter can be read but not modified
void printValue(const int32_t* value, const uint8_t* flags) {
    int32_t copy = (*value);
    uint8_t flagCopy = (*flags);
}

void main(void) {
    int32_t x = 42;
    uint8_t f = 0xFF;
    printValue(&x, &f);
}
