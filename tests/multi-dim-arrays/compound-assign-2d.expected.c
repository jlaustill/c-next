/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: Compound assignment on multi-dimensional arrays
// Verifies fix for line 4073 in CodeGenerator.ts
uint8_t matrix[4][4] = {0};

int32_t main(void) {
    matrix[0][0] = 10;
    matrix[1][1] = 20;
    matrix[2][2] = 100;
    matrix[0][0] += 5;
    matrix[1][1] -= 8;
    matrix[2][2] *= 2;
    if (matrix[0][0] != 15) {
        return 1;
    }
    if (matrix[1][1] != 12) {
        return 1;
    }
    if (matrix[2][2] != 200) {
        return 1;
    }
    return 0;
}
