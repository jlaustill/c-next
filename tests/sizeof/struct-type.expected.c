/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-023: sizeof on struct types
typedef struct {
    int32_t x;
    int32_t y;
} Point;

int main(void) {
    uint32_t pointSize = sizeof(Point);
}
