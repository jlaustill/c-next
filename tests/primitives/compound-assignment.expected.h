#ifndef COMPOUND_ASSIGNMENT_TEST_H
#define COMPOUND_ASSIGNMENT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t brightness;
extern uint16_t sensorValue;
extern uint32_t counter;

#ifdef __cplusplus
}
#endif

#endif /* COMPOUND_ASSIGNMENT_TEST_H */
