/**
 * Generated by C-Next Transpiler from: scope-enum-access.test.cnx
 * A safer C for embedded systems
 */

#include "scope-enum-access.test.hpp"

#include <stdint.h>

// test-execution
// Tests: Enum access inside scopes without global. prefix when unambiguous
/* Scope: Test */

uint32_t Test_checkRed(EColor c) {
    if (c == EColor_RED) {
        return 1;
    }
    return 0;
}

int main(void) {
    EColor c = EColor_RED;
    uint32_t result = Test_checkRed(c);
    if (result != 1) {
        return 1;
    }
    return 0;
}
