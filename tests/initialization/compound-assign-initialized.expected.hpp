#ifndef COMPOUND_ASSIGN_INITIALIZED_TEST_H
#define COMPOUND_ASSIGN_INITIALIZED_TEST_H

/**
 * Generated by C-Next Transpiler from: compound-assign-initialized.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    uint32_t x;
    uint32_t y;
} Point;

#ifdef __cplusplus
}
#endif

#endif /* COMPOUND_ASSIGN_INITIALIZED_TEST_H */
