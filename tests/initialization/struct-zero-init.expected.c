/**
 * Generated by C-Next Transpiler from: struct-zero-init.test.cnx
 * A safer C for embedded systems
 */

#include "struct-zero-init.test.h"

#include <stdint.h>
#include <stdbool.h>

// test-execution
// ADR-015: Struct zero initialization
// Tests: struct members are automatically zero-initialized
/* Scope: ZeroInit */

Point origin = {0};

ZeroInit_Config settings = {0};

int main(void) {
    if (origin.x == 0 && origin.y == 0) {
        if (settings.baudRate == 0 && settings.dataBits == 0 && settings.enabled == false) {
            return 0;
        }
    }
    return 1;
}
