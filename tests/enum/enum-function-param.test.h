#ifndef ENUM_FUNCTION_PARAM_TEST_H
#define ENUM_FUNCTION_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Status_OK = 0,
    Status_WARNING = 1,
    Status_ERROR = 2,
    Status_CRITICAL = 3
} Status;

#ifdef __cplusplus
}
#endif

#endif /* ENUM_FUNCTION_PARAM_TEST_H */
