/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef NAMED_TAG_TEST_H
#define NAMED_TAG_TEST_H

#include <stdint.h>

#include "bugs/issue-834-struct-tag-cast/named-tag.h"

void test(void);

#endif
