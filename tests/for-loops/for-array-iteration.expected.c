/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// For loop tests: Array iteration with .length
// Tests: using array .length property for loop bounds
int main(void) {
    uint8_t buffer[16] = {0};
    buffer[0] = 0U;
    for (uint32_t i = 0; i < 16; i = i + 1) {
        buffer[i] = 0U;
    }
}
