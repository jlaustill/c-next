#ifndef FOR_EMPTY_PARTS_TEST_H
#define FOR_EMPTY_PARTS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t globalCounter;

#ifdef __cplusplus
}
#endif

#endif /* FOR_EMPTY_PARTS_TEST_H */
