#ifndef CONFIG_H
#define CONFIG_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    int32_t value;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* CONFIG_H */
