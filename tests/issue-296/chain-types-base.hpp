#ifndef CHAIN_TYPES_BASE_H
#define CHAIN_TYPES_BASE_H

/**
 * Generated by C-Next Transpiler from: chain-types-base.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Coordinate {
    int32_t x;
    int32_t y;
    int32_t z;
} Coordinate;

#ifdef __cplusplus
}
#endif

#endif /* CHAIN_TYPES_BASE_H */
