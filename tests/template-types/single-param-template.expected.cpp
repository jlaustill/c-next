/**
 * Generated by C-Next Transpiler from: single-param-template.test.cnx
 * A safer C for embedded systems
 */

// Issue #291: Test single parameter template type
// Tests template with a single type parameter like Vector<u32>
#include "template-stubs.h"

// Single template parameter with identifier
Container<Element> singleParam = {};

// Single template parameter with C++ compatible type (uint32_t)
// Note: C-Next u32 maps to uint32_t in generated code
Vector<uint32_t> numbers = {};

int main(void) {
}
