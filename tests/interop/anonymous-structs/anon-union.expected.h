/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef ANON_UNION_TEST_H
#define ANON_UNION_TEST_H

#include "anon_types.h"

void test_anon_union_int(void);
void test_anon_union_point(void);

#endif // ANON_UNION_TEST_H
