#ifndef LED_TEST_H
#define LED_TEST_H

/**
 * Generated by C-Next Transpiler from: led.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void LED_on(void);
void LED_off(void);
uint8_t LED_getState(void);
void LED_toggle(void);

#ifdef __cplusplus
}
#endif

#endif /* LED_TEST_H */
