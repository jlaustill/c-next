#ifndef STRING_SIZE_TEST_H
#define STRING_SIZE_TEST_H

/**
 * Generated by C-Next Transpiler from: string-size.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char buffer[51];

#ifdef __cplusplus
}
#endif

#endif /* STRING_SIZE_TEST_H */
