#ifndef CALLBACK_POINTER_SCOPE_TEST_H
#define CALLBACK_POINTER_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: callback-pointer-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "widget.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Renderer_my_flush(widget_t* w, const rect_t* area, uint8_t* buf);
void Renderer_init(void);

#ifdef __cplusplus
}
#endif

#endif /* CALLBACK_POINTER_SCOPE_TEST_H */
