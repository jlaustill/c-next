#ifndef VALID_FGETS_ELSE_TEST_H
#define VALID_FGETS_ELSE_TEST_H

/**
 * Generated by C-Next Transpiler from: valid-fgets-else.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern char line[129];

#ifdef __cplusplus
}
#endif

#endif /* VALID_FGETS_ELSE_TEST_H */
