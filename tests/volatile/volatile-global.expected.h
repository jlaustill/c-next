#ifndef VOLATILE_GLOBAL_TEST_H
#define VOLATILE_GLOBAL_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t status_flag;
extern uint8_t byte_flag;
extern bool ready_flag;

#ifdef __cplusplus
}
#endif

#endif /* VOLATILE_GLOBAL_TEST_H */
