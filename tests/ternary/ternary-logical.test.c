/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-022: Ternary with logical operators
// && and || in condition
void test(void) {
    uint32_t a = 5;
    uint32_t b = 10;
    uint32_t both = (a > 0 && b > 0) ? 1 : 0;
    uint32_t either = (a == 0 || b == 0) ? 1 : 0;
    uint32_t complex = (a > 0 && b > 0 || a < 0) ? a : b;
}
