#ifndef SCOPED_STRUCT_LOOPS_TEST_H
#define SCOPED_STRUCT_LOOPS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Sensor_Reading {
    uint16_t value;
    uint8_t channel;
} Sensor_Reading;

/* External variables */
extern Sensor_Reading Sensor_buffer[4];
extern uint8_t Sensor_count;

/* Function prototypes */
void Sensor_addReading(uint16_t val, uint8_t ch);
uint16_t Sensor_sumValues(void);
void Sensor_clear(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPED_STRUCT_LOOPS_TEST_H */
