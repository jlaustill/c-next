/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// ADR-025: Exhaustive Enum Switch Test
// Tests switch with all enum variants covered
typedef enum {
    EState_IDLE = 0,
    EState_RUNNING = 1,
    EState_STOPPED = 2
} EState;

void onIdle(void) {
}

void onActive(void) {
}

void onStopped(void) {
}

void handleState(EState state) {
    switch (state) {
        case EState_IDLE: {
            onIdle();
            break;
        }
        case EState_RUNNING: {
            onActive();
            break;
        }
        case EState_STOPPED: {
            onStopped();
            break;
        }
    }
}
