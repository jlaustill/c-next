#ifndef U64_ARRAY_INIT_TEST_H
#define U64_ARRAY_INIT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint64_t timestamps[4];
extern uint64_t counters[5];
extern uint64_t buffer[100];
extern uint64_t ones[50];
extern const uint64_t factorials[10];

#ifdef __cplusplus
}
#endif

#endif /* U64_ARRAY_INIT_TEST_H */
