#ifndef SCOPE_ARRAY_PARAM_TEST_H
#define SCOPE_ARRAY_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-array-param.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void Test_writeToArray(uint8_t data[8], uint8_t value);
void Test_writeAtIndex(uint8_t data[8], uint32_t index, uint8_t value);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_ARRAY_PARAM_TEST_H */
