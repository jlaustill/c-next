#ifndef DO_WHILE_EQUALITY_TEST_H
#define DO_WHILE_EQUALITY_TEST_H

/**
 * Generated by C-Next Transpiler from: do-while-equality.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t END_MARKER;

#ifdef __cplusplus
}
#endif

#endif /* DO_WHILE_EQUALITY_TEST_H */
