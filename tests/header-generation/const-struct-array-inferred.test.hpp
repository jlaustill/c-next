#ifndef CONST_STRUCT_ARRAY_INFERRED_TEST_H
#define CONST_STRUCT_ARRAY_INFERRED_TEST_H

/**
 * Generated by C-Next Transpiler from: const-struct-array-inferred.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TItem {
    uint32_t id;
    uint16_t value;
} TItem;

/* External variables */
extern const TItem ITEMS[3];
extern TItem mutableItems[2];
extern const uint8_t SIZES[4];
extern const int32_t EXPLICIT[2];
extern const uint8_t ITEM_COUNT;

#ifdef __cplusplus
}
#endif

#endif /* CONST_STRUCT_ARRAY_INFERRED_TEST_H */
