#ifndef SWITCH_BRANCH_INIT_TEST_H
#define SWITCH_BRANCH_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: switch-branch-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    Mode_OFF = 0,
    Mode_LOW = 1,
    Mode_MEDIUM = 2,
    Mode_HIGH = 3
} Mode;

#ifdef __cplusplus
}
#endif

#endif /* SWITCH_BRANCH_INIT_TEST_H */
