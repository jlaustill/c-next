/**
 * Generated by C-Next Transpiler from: transitive-mutation.test.cnx
 * A safer C for embedded systems
 */

#include "transitive-mutation.test.hpp"

#include <stdint.h>

// Issue #797: Transpiler incorrectly infers const when function delegates mutation
/* Scope: TransMutation */

/* Scope: Test */

void Test_fillData(TransMutation_Data& d) {
    d.value = 42U;
}

void Test_loadData(TransMutation_Data& d) {
    Test_fillData(d);
}

int main(void) {
    TransMutation_Data d = { .value = 0U };
    if (d.value != 0) return 1;
    Test_loadData(d);
    if (d.value != 42) return 2;
    return 0;
}
