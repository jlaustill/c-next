#ifndef ATOMIC_WITH_CLAMP_TEST_H
#define ATOMIC_WITH_CLAMP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t brightness;
extern uint16_t volume;
extern uint32_t counter;
extern int8_t temperature;
extern int16_t offset;
extern int32_t position;

#ifdef __cplusplus
}
#endif

#endif /* ATOMIC_WITH_CLAMP_TEST_H */
