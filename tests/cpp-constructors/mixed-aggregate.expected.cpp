/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// test-cpp-only
// test-execution
// Issue #924: Mixed aggregate and non-aggregate types
// Aggregate types can use designated initializers, non-aggregates cannot
#include "DefaultConstructible.hpp"
#include "AggregateType.hpp"

#include <stdint.h>

int main(void) {
    DefaultConstructible nonAgg = {};
    nonAgg.value = 42;
    nonAgg.name = "test";
    AggregateType agg = (AggregateType){ .value = 99, .label = "agg" };
    if (nonAgg.value != 42) return 1;
    if (agg.value != 99) return 2;
    return 0;
}
