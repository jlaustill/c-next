#ifndef ATOMIC_WITH_WRAP_TEST_H
#define ATOMIC_WITH_WRAP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint8_t tick8;
extern volatile uint16_t tick16;
extern volatile uint32_t tick32;
extern volatile uint8_t sequenceNumber;
extern volatile uint16_t frameCounter;

#ifdef __cplusplus
}
#endif

#endif /* ATOMIC_WITH_WRAP_TEST_H */
