#ifndef DO_WHILE_LOGICAL_TEST_H
#define DO_WHILE_LOGICAL_TEST_H

/**
 * Generated by C-Next Transpiler from: do-while-logical.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint32_t MAX_RETRIES;

#ifdef __cplusplus
}
#endif

#endif /* DO_WHILE_LOGICAL_TEST_H */
