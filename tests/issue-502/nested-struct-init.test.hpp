#ifndef NESTED_STRUCT_INIT_TEST_H
#define NESTED_STRUCT_INIT_TEST_H

/**
 * Generated by C-Next Transpiler from: nested-struct-init.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Wrapper {
    SeaDash::Parse::ParseResult result;
} Wrapper;

/* External variables */
extern Wrapper w;

#ifdef __cplusplus
}
#endif

#endif /* NESTED_STRUCT_INIT_TEST_H */
