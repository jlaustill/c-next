#ifndef BASIC_NESTING_TEST_H
#define BASIC_NESTING_TEST_H

/**
 * Generated by C-Next Transpiler from: basic-nesting.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Line {
    Point start;
    Point end;
} Line;
typedef struct Rectangle {
    Point topLeft;
    Point bottomRight;
} Rectangle;

/* External variables */
extern Line segment;
extern Rectangle bounds;

#ifdef __cplusplus
}
#endif

#endif /* BASIC_NESTING_TEST_H */
