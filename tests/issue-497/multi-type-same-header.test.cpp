/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "multi-type-same-header.test.h"

// Test: Multiple types from same C header should only include header once
#include "multi-type-same-header.h"

/* Scope: Geometry */

Point Geometry_getOrigin(void) {
    Point p = (Point){ .x = 0, .y = 0 };
    return p;
}

Line Geometry_makeLine(const Point& start, const Point& end) {
    Line l = (Line){ .start = start, .end = end };
    return l;
}

int main(void) {
    Point p = Geometry_getOrigin();
    Line l = Geometry_makeLine(p, p);
}
