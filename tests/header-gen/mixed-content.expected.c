/**
 * Generated by C-Next Transpiler from: mixed-content.test.cnx
 * A safer C for embedded systems
 */

#include "mixed-content.test.h"

// Issue #403: Mixed content header generation test
// Tests header generation with enums, structs, and functions.
/* Scope: HeaderMixed */

HeaderMixed_Config globalConfig = (HeaderMixed_Config){ .timeout = 1000U, .retries = 3U, .status = EStatus_STATUS_IDLE };

void initConfig(void) {
    globalConfig.timeout = 5000U;
    globalConfig.retries = 5U;
    globalConfig.status = EStatus_STATUS_IDLE;
}

EStatus getStatus(void) {
    return globalConfig.status;
}

void setStatus(EStatus newStatus) {
    globalConfig.status = newStatus;
}

int main(void) {
    initConfig();
    setStatus(EStatus_STATUS_RUNNING);
}
