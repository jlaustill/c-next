/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Issue #296: Type definitions for cross-file struct usage
// This file defines struct types used by other modules
typedef struct AppData {
    float humidity;
    float temperature;
} AppData;
