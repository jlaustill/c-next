/**
 * Generated by C-Next Transpiler from: header-namespace-extern.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #522 - C++ namespace types should NOT appear in extern "C" headers
// The header should filter out Lib_Sub_Data because it's a C++ namespaced type
#include "Lib.hpp"

#include <stdbool.h>

// Variable with C++ namespaced struct type
Lib::Sub::Data globalData = (Lib::Sub::Data){ .value = 42, .active = true };
