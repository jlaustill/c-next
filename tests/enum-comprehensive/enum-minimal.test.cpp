/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "enum-minimal.test.hpp"

#include <stdint.h>

// test-execution
// Tests: Minimal enum test
/* Scope: Motor */
static Motor_EMode Motor_mode = Motor_EMode_OFF;

Motor_EMode Motor_getMode(void) {
    return Motor_mode;
}

int main(void) {
    Motor_EMode motorMode = Motor_getMode();
    if (motorMode != Motor_EMode_OFF) return 1;
    return 0;
}
