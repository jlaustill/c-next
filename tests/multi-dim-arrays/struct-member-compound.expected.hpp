#ifndef STRUCT_MEMBER_COMPOUND_TEST_H
#define STRUCT_MEMBER_COMPOUND_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-member-compound.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Buffer {
    uint8_t data[8];
    int32_t counts[4];
} Buffer;

/* External variables */
extern Buffer buf;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_MEMBER_COMPOUND_TEST_H */
