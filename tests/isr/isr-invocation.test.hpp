#ifndef ISR_INVOCATION_TEST_H
#define ISR_INVOCATION_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t invokeCallCount;
extern uint32_t invokeLastHandler;
extern ISR globalHandler;

#ifdef __cplusplus
}
#endif

#endif /* ISR_INVOCATION_TEST_H */
