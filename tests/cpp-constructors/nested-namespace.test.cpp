/**
 * Generated by C-Next Transpiler from: nested-namespace.test.cnx
 * A safer C for embedded systems
 */

// test-cpp-only
// test-execution
// Issue #924: Nested namespace C++ class with constructor
// Classes in nested namespaces should also use field assignment pattern
#include "NestedNamespace.hpp"

#include <stdint.h>

int main(void) {
    Outer::Inner::Widget w = {};
    w.x = 10;
    w.y = 20;
    if (w.x != 10) return 1;
    if (w.y != 20) return 2;
    Outer::Inner::Widget w2 = {};
    w2.x = 100;
    w2.y = 200;
    if (w2.x != 100) return 3;
    if (w2.y != 200) return 4;
    return 0;
}
