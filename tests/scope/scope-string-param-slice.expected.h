#ifndef SCOPE_STRING_PARAM_SLICE_TEST_H
#define SCOPE_STRING_PARAM_SLICE_TEST_H

/**
 * Generated by C-Next Transpiler from: scope-string-param-slice.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
uint32_t StringSliceTest_testSliceAssignment(void);

#ifdef __cplusplus
}
#endif

#endif /* SCOPE_STRING_PARAM_SLICE_TEST_H */
