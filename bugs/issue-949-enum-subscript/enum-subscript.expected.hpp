#ifndef ENUM_SUBSCRIPT_TEST_H
#define ENUM_SUBSCRIPT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EColor_RED = 0,
    EColor_GREEN = 1,
    EColor_BLUE = 2,
    EColor_COUNT = 3
} EColor;

/* Struct definitions */
typedef struct TValue {
    uint32_t data;
} TValue;

/* External variables */
extern TValue values[4];

/* Function prototypes */
uint32_t Test_getValue(EColor color);
void Test_setValue(EColor color, uint32_t val);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_SUBSCRIPT_TEST_H */
