#ifndef ENUM_SCOPE_RETURNS_GLOBAL_TEST_H
#define ENUM_SCOPE_RETURNS_GLOBAL_TEST_H

/**
 * Generated by C-Next Transpiler from: enum-scope-returns-global.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EGlobal_A = 0,
    EGlobal_B = 1
} EGlobal;

/* Function prototypes */
EGlobal Test_getGlobalEnum(void);

#ifdef __cplusplus
}
#endif

#endif /* ENUM_SCOPE_RETURNS_GLOBAL_TEST_H */
