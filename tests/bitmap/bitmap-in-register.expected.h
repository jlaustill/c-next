#ifndef BITMAP_IN_REGISTER_TEST_H
#define BITMAP_IN_REGISTER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Bitmaps */
/* Bitmap: MotorControl
 *   Running: bit 0
 *   Direction: bit 1
 *   Fault: bit 2
 *   Mode: bits 3-5 (3 bits)
 *   Reserved: bits 6-7 (2 bits)
 */
typedef uint8_t MotorControl;

#ifdef __cplusplus
}
#endif

#endif /* BITMAP_IN_REGISTER_TEST_H */
