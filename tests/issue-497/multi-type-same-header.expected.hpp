#ifndef MULTI_TYPE_SAME_HEADER_TEST_H
#define MULTI_TYPE_SAME_HEADER_TEST_H

/**
 * Generated by C-Next Transpiler from: multi-type-same-header.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "multi-type-same-header.h"

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
Point Geometry_getOrigin(void);
Line Geometry_makeLine(const Point& start, const Point& end);

#ifdef __cplusplus
}
#endif

#endif /* MULTI_TYPE_SAME_HEADER_TEST_H */
