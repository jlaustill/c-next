#ifndef FOR_INSIDE_SCOPE_TEST_H
#define FOR_INSIDE_SCOPE_TEST_H

/**
 * Generated by C-Next Transpiler from: for-inside-scope.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint32_t globalSum;

/* Function prototypes */
void Calculator_sumToN(uint32_t n);
void Calculator_factorial(uint32_t n);
uint32_t Calculator_getResult(void);
void ArrayOps_initialize(void);
void ArrayOps_computeSum(void);
uint32_t ArrayOps_getSum(void);

#ifdef __cplusplus
}
#endif

#endif /* FOR_INSIDE_SCOPE_TEST_H */
