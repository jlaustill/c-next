/**
 * Generated by C-Next Transpiler from: enum-direct.test.cnx
 * A safer C for embedded systems
 */

#include "enum-direct.test.h"

#include <stdint.h>

// test-execution
// Tests: Direct enum assignment (no method call)
/* Scope: Motor */

int main(void) {
    Motor_EMode motorMode = Motor_EMode_OFF;
    if (motorMode != Motor_EMode_OFF) return 1;
    return 0;
}
