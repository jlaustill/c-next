#ifndef ISSUE_308_UNNECESSARY_ADDRESS_OF_TEST_H
#define ISSUE_308_UNNECESSARY_ADDRESS_OF_TEST_H

/**
 * Generated by C-Next Transpiler from: issue-308-unnecessary-address-of.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct DataResult {
    uint8_t errorCode;
    uint8_t data[6];
    uint8_t dataLen;
} DataResult;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_308_UNNECESSARY_ADDRESS_OF_TEST_H */
