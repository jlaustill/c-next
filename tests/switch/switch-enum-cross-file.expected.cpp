/**
 * Generated by C-Next Transpiler from: switch-enum-cross-file.test.cnx
 * A safer C for embedded systems
 */

// Issue #471: Cross-file enum resolution in case labels
// Tests that enum values from included files get resolved correctly
#include "switch-enum-cross-file-types.hpp"

#include <stdint.h>

uint32_t classify(EStatus status) {
    switch (status) {
        case EStatus_PENDING: {
            return 1;
            break;
        }
        case EStatus_ACTIVE: {
            return 2;
            break;
        }
        case EStatus_COMPLETED: {
            return 3;
            break;
        }
        default: {
            break;
        }
    }
    return 0;
}
