#ifndef EXTERNAL_TEMPLATE_INTEROP_TEST_H
#define EXTERNAL_TEMPLATE_INTEROP_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
void CANHandler_init(void);

#ifdef __cplusplus
}
#endif

#endif /* EXTERNAL_TEMPLATE_INTEROP_TEST_H */
