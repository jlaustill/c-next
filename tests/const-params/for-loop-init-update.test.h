#ifndef FOR_LOOP_INIT_UPDATE_TEST_H
#define FOR_LOOP_INIT_UPDATE_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    uint32_t value;
} Config;

/* Function prototypes */
uint8_t Handler_setValue(Config& cfg, uint32_t val);
uint32_t Handler_getNext(Config& cfg, uint32_t current);

#ifdef __cplusplus
}
#endif

#endif /* FOR_LOOP_INIT_UPDATE_TEST_H */
