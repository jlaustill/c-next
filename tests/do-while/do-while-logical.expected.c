/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <stdbool.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_add_u32(uint32_t a, uint32_t b) {
    if (a > UINT32_MAX - b) return UINT32_MAX;
    return a + b;
}

// ADR-027: Do-while with logical operators
const uint32_t MAX_RETRIES = 5;

void retryLoop(void) {
    uint32_t attempts = 0;
    bool success = false;
    do {
        attempts = cnx_clamp_add_u32(attempts, 1);
        success = true;
    } while (!success && attempts < MAX_RETRIES);
}

