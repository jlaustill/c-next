/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// test-execution
// Regression test for issue #68: Real-world serialization pattern
// Verifies config.magic.length correctly returns 32 (was returning 0)
typedef struct Config {
    uint32_t magic;
    uint8_t version;
} Config;

int main(void) {
    Config config = {0};
    config.magic = 0x12345678U;
    config.version = 0x42U;
    uint32_t length = 32 / 8U;
    if (length != 4) return 1;
    length = 8 / 8U;
    if (length != 1) return 2;
    uint32_t bits = 32;
    if (bits != 32) return 3;
    bits = 8;
    if (bits != 8) return 4;
    return 0;
}
