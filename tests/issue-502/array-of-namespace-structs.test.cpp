/**
 * Generated by C-Next Transpiler from: array-of-namespace-structs.test.cnx
 * A safer C for embedded systems
 */

// test-transpile-only
// Tests: Issue #502 - Array of C++ namespaced structs
#include "SeaDash.hpp"

#include <stdbool.h>

// Array of C++ namespace structs
SeaDash::Parse::ParseResult results[3] = {(SeaDash::Parse::ParseResult){ .data = {0}, .count = 0, .success = false }, (SeaDash::Parse::ParseResult){ .data = {1}, .count = 1, .success = true }, (SeaDash::Parse::ParseResult){ .data = {2}, .count = 2, .success = true }};
