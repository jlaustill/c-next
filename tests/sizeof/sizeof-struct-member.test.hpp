#ifndef SIZEOF_STRUCT_MEMBER_TEST_H
#define SIZEOF_STRUCT_MEMBER_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Sensor {
    uint8_t id;
    uint16_t value;
    uint32_t timestamp;
    float temperature;
} Sensor;
typedef struct DataBuffer {
    uint8_t data[64];
    uint32_t len;
} DataBuffer;

/* External variables */
extern Point globalPoint;
extern Sensor globalSensor;
extern DataBuffer globalBuffer;

#ifdef __cplusplus
}
#endif

#endif /* SIZEOF_STRUCT_MEMBER_TEST_H */
