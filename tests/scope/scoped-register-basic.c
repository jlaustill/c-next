/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// Test: Basic scoped register declaration and access
/* Scope: Teensy4 */

/* Register: Teensy4_GPIO7 @ 0x42004000 */
#define Teensy4_GPIO7_DR (*(volatile uint32_t*)(0x42004000 + 0x00))
#define Teensy4_GPIO7_DR_SET (*(volatile uint32_t*)(0x42004000 + 0x84))
#define Teensy4_GPIO7_DR_TOGGLE (*(volatile uint32_t*)(0x42004000 + 0x8C))


void main(void) {
    Teensy4_GPIO7_DR_SET = 8;
}
