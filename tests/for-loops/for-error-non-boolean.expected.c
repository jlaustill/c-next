/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_add_u32(uint32_t a, uint64_t b) {
    if (b > UINT32_MAX - a) return UINT32_MAX;
    return a + (uint32_t)b;
}

// Coverage: Section 7.4 - for loop non-boolean condition error
// Tests: Error when using non-boolean expression as for condition
void test(void) {
    uint32_t count = 0;
    for (uint32_t i = 10; i; i = i - 1) {
        count = cnx_clamp_add_u32(count, 1);
    }
}
