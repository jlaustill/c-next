#ifndef FUNC_RETURN_MEMBER_CPP_TEST_H
#define FUNC_RETURN_MEMBER_CPP_TEST_H

/**
 * Generated by C-Next Transpiler from: func-return-member-cpp.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>
#include "func-return-member-cpp.h"

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern DeviceConfig globalConfig;

#ifdef __cplusplus
}
#endif

#endif /* FUNC_RETURN_MEMBER_CPP_TEST_H */
