#ifndef F32_ALL_CONTEXTS_TEST_H
#define F32_ALL_CONTEXTS_TEST_H

/**
 * Generated by C-Next Transpiler from: f32-all-contexts.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    float x;
    float y;
} Point;

/* External variables */
extern float global_f;
extern float global_uninit;
extern float samples[4];

#ifdef __cplusplus
}
#endif

#endif /* F32_ALL_CONTEXTS_TEST_H */
