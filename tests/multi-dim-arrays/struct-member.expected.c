/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-036: Multi-dimensional arrays in structs
typedef struct {
    uint32_t width;
    uint32_t height;
    uint8_t pixels[240][320];
} Image;

Image screen = {0};

int32_t main(void) {
    screen.width = 320;
    screen.height = 240;
    screen.pixels[0][0] = 0;
    screen.pixels[239][319] = 255;
    return 0;
}
