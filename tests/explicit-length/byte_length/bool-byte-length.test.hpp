#ifndef BOOL_BYTE_LENGTH_TEST_H
#define BOOL_BYTE_LENGTH_TEST_H

/**
 * Generated by C-Next Transpiler from: bool-byte-length.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct TestStruct {
    bool flag;
} TestStruct;

/* External variables */
extern bool globalBool;

#ifdef __cplusplus
}
#endif

#endif /* BOOL_BYTE_LENGTH_TEST_H */
