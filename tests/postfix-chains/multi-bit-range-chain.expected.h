#ifndef MULTI_BIT_RANGE_CHAIN_TEST_H
#define MULTI_BIT_RANGE_CHAIN_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Device {
    uint8_t control;
    uint16_t status;
    uint32_t config;
} Device;

/* External variables */
extern Device devices[4];
extern uint8_t flags;
extern uint16_t settings;
extern uint32_t registers;

#ifdef __cplusplus
}
#endif

#endif /* MULTI_BIT_RANGE_CHAIN_TEST_H */
