/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "enum-cross-scope-return.test.h"

#include <stdint.h>

// test-execution
// Tests: Cross-scope method call returning enum (global.Scope.method() pattern)
/* Scope: Provider */

ECategory Provider_getCategory(void) {
    return ECategory_CAT_A;
}

/* Scope: Consumer */

uint32_t Consumer_test(void) {
    ECategory cat = Provider_getCategory();
    if (cat == ECategory_CAT_A) {
        return 0;
    }
    return 1;
}

int main(void) {
    uint32_t result = Consumer_test();
    return result;
}
