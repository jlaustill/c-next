/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef SIMPLE_INIT_TEST_H
#define SIMPLE_INIT_TEST_H

#include "anon_types.h"

void test_simple_init(void);
void test_partial_init(void);

#endif // SIMPLE_INIT_TEST_H
