/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef FLOAT_BIT_UNION_PUNNING_TEST_H
#define FLOAT_BIT_UNION_PUNNING_TEST_H

#include <stdint.h>

#endif // FLOAT_BIT_UNION_PUNNING_TEST_H
