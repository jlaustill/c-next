/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-014: Basic struct declaration
// Tests: struct definition and declaration
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;

typedef struct Color {
    uint8_t r;
    uint8_t g;
    uint8_t b;
    uint8_t a;
} Color;

int main(void) {
    Point p = {0};
    Color c = {0};
}
