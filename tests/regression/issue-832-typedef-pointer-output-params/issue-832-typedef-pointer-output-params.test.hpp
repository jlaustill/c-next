#ifndef ISSUE_832_TYPEDEF_POINTER_OUTPUT_PARAMS_TEST_H
#define ISSUE_832_TYPEDEF_POINTER_OUTPUT_PARAMS_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External type dependencies - include appropriate headers */
typedef struct handle_t handle_t;

/* External variables */
extern handle_t my_handle;

#ifdef __cplusplus
}
#endif

#endif /* ISSUE_832_TYPEDEF_POINTER_OUTPUT_PARAMS_TEST_H */
