#ifndef SIZEOF_IN_EXPRESSION_TEST_H
#define SIZEOF_IN_EXPRESSION_TEST_H

/**
 * Generated by C-Next Transpiler from: sizeof-in-expression.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Header {
    uint32_t magic;
    uint32_t version;
    uint32_t length;
} Header;

#ifdef __cplusplus
}
#endif

#endif /* SIZEOF_IN_EXPRESSION_TEST_H */
