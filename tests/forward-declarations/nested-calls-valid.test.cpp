/**
 * Generated by C-Next Transpiler from: nested-calls-valid.test.cnx
 * A safer C for embedded systems
 */

// ADR-030: Valid nested call chain
// Tests: chain of calls where each is defined before caller
void level3(void) {
}

void level2(void) {
    level3();
}

void level1(void) {
    level2();
}

int main(void) {
    level1();
}
