/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

typedef struct Config {
    int32_t value;
} Config;
