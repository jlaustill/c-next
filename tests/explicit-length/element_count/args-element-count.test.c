/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>
#include <string.h>

// test-transpile-only
// Tests args.element_count property (ADR-058)
// args.element_count returns argc
int main(int argc, char *argv[]) {
    uint32_t count = argc;
    if (count < 1) {
        return 1;
    }
    return 0;
}
