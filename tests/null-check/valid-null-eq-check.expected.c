/**
 * Generated by C-Next Transpiler from: valid-null-eq-check.test.cnx
 * A safer C for embedded systems
 */

// ADR-046: Valid NULL check using = (equality) comparison with c_ prefix
// cppcheck-suppress misra-c2012-21.6
#include <stdio.h>

#include <string.h>

char buffer[65] = "";

void handleEof(void) {
    char* c_result = fgets(buffer, 65, stdin);
    if (c_result == NULL) {
        (void)printf("End of input\n");
    }
}
