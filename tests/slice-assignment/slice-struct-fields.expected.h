#ifndef SLICE_STRUCT_FIELDS_TEST_H
#define SLICE_STRUCT_FIELDS_TEST_H

/**
 * Generated by C-Next Transpiler from: slice-struct-fields.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct SliceFields_Config {
    uint32_t magic;
    uint16_t version;
    uint8_t flags;
    uint64_t timestamp;
} SliceFields_Config;

#ifdef __cplusplus
}
#endif

#endif /* SLICE_STRUCT_FIELDS_TEST_H */
