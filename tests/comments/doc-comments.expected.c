/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Doc Comments Test (ADR-043)
// Tests that triple-slash converts to Doxygen format
#include <stdint.h>

#include <stdint.h>

/**
 * Doubles the input value
 * @param value The input to double
 * @return The doubled value
 */
uint32_t doubleValue(uint32_t value) {
    return value * 2;
}

/** Maximum buffer size constant */
const uint32_t MAX_BUFFER = 256U;
