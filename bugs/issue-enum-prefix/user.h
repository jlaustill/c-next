#ifndef USER_H
#define USER_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Config {
    EPressureType pType;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* USER_H */
