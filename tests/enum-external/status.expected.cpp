/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

// Helper file: defines second enum for multiple-enum testing
typedef enum {
    EStatus_STATUS_IDLE = 0,
    EStatus_STATUS_ACTIVE = 1,
    EStatus_STATUS_ERROR = 2
} EStatus;
