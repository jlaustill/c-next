/**
 * Generated by C-Next Transpiler from: math-utils.cnx
 * A safer C for embedded systems
 */

#include "math-utils.h"

#include <stdint.h>

// Helper file: math utilities for cross-file function test
/* Scope: MathUtils */

uint32_t MathUtils_add(uint32_t a, uint32_t b) {
    return a + b;
}

uint32_t MathUtils_multiply(uint32_t a, uint32_t b) {
    return a * b;
}
