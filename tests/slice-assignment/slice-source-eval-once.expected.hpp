#ifndef SLICE_SOURCE_EVAL_ONCE_TEST_H
#define SLICE_SOURCE_EVAL_ONCE_TEST_H

/**
 * Generated by C-Next Transpiler from: slice-source-eval-once.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern uint8_t sliceSourceCallCount;

#ifdef __cplusplus
}
#endif

#endif /* SLICE_SOURCE_EVAL_ONCE_TEST_H */
