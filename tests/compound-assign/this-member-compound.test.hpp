#ifndef THIS_MEMBER_COMPOUND_TEST_H
#define THIS_MEMBER_COMPOUND_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Function prototypes */
int32_t Calculator_runAllTests(void);

#ifdef __cplusplus
}
#endif

#endif /* THIS_MEMBER_COMPOUND_TEST_H */
