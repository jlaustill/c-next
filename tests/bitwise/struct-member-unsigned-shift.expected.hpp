#ifndef STRUCT_MEMBER_UNSIGNED_SHIFT_TEST_H
#define STRUCT_MEMBER_UNSIGNED_SHIFT_TEST_H

/**
 * Generated by C-Next Transpiler from: struct-member-unsigned-shift.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Data {
    uint8_t value;
} Data;

#ifdef __cplusplus
}
#endif

#endif /* STRUCT_MEMBER_UNSIGNED_SHIFT_TEST_H */
