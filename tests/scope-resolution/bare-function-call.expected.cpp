/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include "bare-function-call.test.hpp"

#include <stdint.h>

// Test bare function names call scope functions
// test-execution
/* Scope: Calculator */
static uint32_t Calculator_result = 0;

static void Calculator_reset(void) {
    Calculator_result = 0U;
}

static void Calculator_addTen(void) {
    Calculator_result += 10U;
}

void Calculator_compute(void) {
    Calculator_reset();
    Calculator_addTen();
    Calculator_addTen();
}

uint32_t Calculator_getResult(void) {
    return Calculator_result;
}

int main(void) {
    Calculator_compute();
    uint32_t result = Calculator_getResult();
    if (result != 20) return 1;
    return 0;
}
