/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <string.h>

// ADR-045: Test substring extraction
void test(void) {
    char source[65] = "Hello, World!";
    char greeting[6] = "";
        strncpy(greeting, source + 0, 5);
        greeting[5] = '\0';
}
