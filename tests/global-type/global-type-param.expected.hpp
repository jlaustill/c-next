#ifndef GLOBAL_TYPE_PARAM_TEST_H
#define GLOBAL_TYPE_PARAM_TEST_H

/**
 * Generated by C-Next Transpiler from: global-type-param.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Enumerations */
typedef enum {
    EPriority_LOW = 0,
    EPriority_MEDIUM = 1,
    EPriority_HIGH = 2
} EPriority;

/* Function prototypes */
int32_t Processor_process(EPriority priority);

#ifdef __cplusplus
}
#endif

#endif /* GLOBAL_TYPE_PARAM_TEST_H */
