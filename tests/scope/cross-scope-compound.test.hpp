#ifndef CROSS_SCOPE_COMPOUND_TEST_H
#define CROSS_SCOPE_COMPOUND_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern int32_t Counter_value;
extern int32_t Counter_data[3];

/* Function prototypes */
void Manager_incrementCounter(void);
void Manager_incrementCounterArray(void);

#ifdef __cplusplus
}
#endif

#endif /* CROSS_SCOPE_COMPOUND_TEST_H */
