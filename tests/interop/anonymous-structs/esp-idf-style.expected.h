/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef ESP_IDF_STYLE_TEST_H
#define ESP_IDF_STYLE_TEST_H

#include "anon_types.h"

void test_panel_config(void);
void test_panel_minimal(void);

#endif // ESP_IDF_STYLE_TEST_H
