#ifndef PRIMASK_FALLBACK_TEST_H
#define PRIMASK_FALLBACK_TEST_H

/**
 * Generated by C-Next Transpiler from: primask-fallback.test.cnx
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern volatile uint32_t counter;
extern volatile uint16_t ticks;

#ifdef __cplusplus
}
#endif

#endif /* PRIMASK_FALLBACK_TEST_H */
