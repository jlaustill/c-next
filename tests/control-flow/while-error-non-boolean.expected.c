/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#include <stdint.h>

// ADR-044: Overflow helper functions
#include <limits.h>

static inline uint32_t cnx_clamp_sub_u32(uint32_t a, uint64_t b) {
    if (b >= (uint64_t)a) return 0;
    return a - (uint32_t)b;
}

// Coverage: Section 7.2 - while loop non-boolean condition error
// Tests: Error when using non-boolean expression as while condition
void test(void) {
    uint32_t count = 5;
    while (count) {
        count = cnx_clamp_sub_u32(count, 1);
    }
}
