#ifndef REGISTER_MEMORY_WIDTH_TEST_H
#define REGISTER_MEMORY_WIDTH_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

#ifdef __cplusplus
}
#endif

#endif /* REGISTER_MEMORY_WIDTH_TEST_H */
