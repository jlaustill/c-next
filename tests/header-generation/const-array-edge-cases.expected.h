#ifndef CONST_ARRAY_EDGE_CASES_TEST_H
#define CONST_ARRAY_EDGE_CASES_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* External variables */
extern const uint8_t HEX_SIZE;
extern bool hex_arr[16];
extern const uint8_t BUFFER_SIZE;
extern uint8_t Device_buffer[8];

#ifdef __cplusplus
}
#endif

#endif /* CONST_ARRAY_EDGE_CASES_TEST_H */
