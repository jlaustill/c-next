#ifndef AUTO_CONST_STRUCT_TEST_H
#define AUTO_CONST_STRUCT_TEST_H

/**
 * Generated by C-Next Transpiler
 * Header file for cross-language interoperability
 */

#include <stdint.h>
#include <stdbool.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Struct definitions */
typedef struct Point {
    int32_t x;
    int32_t y;
} Point;
typedef struct Config {
    uint32_t value;
    bool enabled;
} Config;

#ifdef __cplusplus
}
#endif

#endif /* AUTO_CONST_STRUCT_TEST_H */
