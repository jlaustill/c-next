/**
 * Generated by C-Next Transpiler
 * A safer C for embedded systems
 */

#ifndef ANON_STRUCT_TEST_H
#define ANON_STRUCT_TEST_H

void test(void);

#endif
